* NGSPICE file created from mult_16x16.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_2 abstract view
.subckt sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

.subckt mult_16x16 VGND VPWR clk in1[0] in1[10] in1[11] in1[12] in1[13] in1[14] in1[15]
+ in1[1] in1[2] in1[3] in1[4] in1[5] in1[6] in1[7] in1[8] in1[9] in2[0] in2[10] in2[11]
+ in2[12] in2[13] in2[14] in2[15] in2[1] in2[2] in2[3] in2[4] in2[5] in2[6] in2[7]
+ in2[8] in2[9] out[0] out[10] out[11] out[12] out[13] out[14] out[15] out[16] out[17]
+ out[18] out[19] out[1] out[20] out[21] out[22] out[23] out[24] out[25] out[26] out[27]
+ out[28] out[29] out[2] out[30] out[31] out[3] out[4] out[5] out[6] out[7] out[8]
+ out[9] rst
XANTENNA__4935__A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3155_ net170 net197 VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__nand2_1
X_3086_ net78 _0449_ _2097_ _2214_ _2213_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_37_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4640__A1 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3988_ _0442_ _0457_ _0459_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_20_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2939_ _2028_ _2029_ _1993_ _1990_ _1988_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__a32oi_4
XANTENNA_fanout215_X net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4609_ _1268_ _1167_ _1267_ _1128_ _1124_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a32o_1
XANTENNA_fanout75_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer7 _0555_ VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_6
X_4960_ _1698_ _1695_ _1752_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o21bai_1
XFILLER_17_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4891_ _1679_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__or2_2
X_3911_ _0620_ _0626_ _0617_ _0625_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__o211a_1
X_3842_ _0546_ _0556_ net281 _0479_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__o211ai_2
XANTENNA__3189__A1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3773_ net234 net110 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_42_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2724_ _1837_ _1838_ _1856_ _1857_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__o211ai_1
X_2655_ _1788_ _1790_ _1784_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__a21bo_2
X_4325_ _0449_ _0559_ _1065_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__o211ai_2
X_2586_ _1129_ _1347_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__xor2_1
Xfanout138 in1_reg\[6\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_2
Xfanout105 in1_reg\[12\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_4
Xfanout127 in1_reg\[8\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_4
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_2
X_4256_ _0946_ _0948_ _0985_ _0987_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nand4_2
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_6
X_4187_ net222 net97 VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__nand2_1
X_3207_ net264 net104 VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__nand2_4
X_3138_ _2159_ _2047_ _2157_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__a21boi_2
X_3069_ _2195_ _2197_ _2191_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__nand3_2
XFILLER_23_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3728__B net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3352__A1 net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3352__B2 net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout78_X net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3591__A1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4110_ _0830_ _0826_ _0822_ _0831_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__o211a_2
XFILLER_68_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4041_ _0724_ _0734_ _0723_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21boi_2
XFILLER_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4943_ _1712_ _1716_ _1736_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__o21a_1
XFILLER_24_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4874_ _1657_ _1658_ _1661_ _1662_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__a31oi_2
XFILLER_20_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3825_ _0540_ _0508_ _0539_ _0328_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand4_4
XANTENNA_fanout125_A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3756_ _0454_ _0443_ _0453_ _0441_ _0440_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a311o_1
X_2707_ _1784_ _1790_ _1787_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__a21oi_2
X_3687_ _0385_ _0386_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__nand2_2
XANTENNA__4379__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2638_ _1585_ _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__nand2_2
X_2569_ _1151_ _1172_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__nor2_1
X_4308_ _0913_ _0919_ _0915_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21oi_4
X_4239_ net143 net183 _0968_ _0970_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_2_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3739__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3458__B net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3876__A2 net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4825__B2 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4038__C1 net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4589__B1 net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4471__C net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4590_ _1350_ _1352_ net77 net69 VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a211o_1
X_3610_ _0185_ _0305_ net234 net115 _0304_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__o2111ai_2
X_3541_ _0234_ _0235_ _0115_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a21oi_1
X_3472_ _2413_ net219 net146 _2414_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__a31o_1
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4024_ _0737_ _0740_ _0742_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__o21ai_1
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4926_ _1718_ _1699_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__nand2b_1
XANTENNA_fanout242_A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4857_ _1550_ _1551_ _1643_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3808_ _0518_ _0519_ net126 net216 VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand4_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4788_ _1567_ _1569_ net106 net180 VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__nand4_1
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3739_ net142 net203 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__nand2_1
XFILLER_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3849__A2 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3651__B net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4274__A2 net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2972_ _2096_ _2098_ _2100_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__and3_1
XANTENNA__2714__C in1_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4711_ _0493_ net68 _1483_ _1484_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__o22ai_2
XANTENNA__3098__B net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4642_ _1408_ net181 net118 _1407_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__and4b_1
X_4573_ _1330_ _1331_ _1294_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__nand3_1
X_3524_ _0176_ _0177_ net320 _0222_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand4_2
XFILLER_6_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3455_ _0154_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__nand2_1
XANTENNA__3561__B net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3386_ _0079_ _0084_ _0087_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__o21ai_1
X_4007_ _0435_ net185 net159 net191 _0437_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a32oi_4
XANTENNA__2608__D net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4909_ net88 net180 net83 net186 VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_33_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input18_A in2[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3464__B1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4716__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3240_ _2369_ _2370_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__nand2_1
X_3171_ _2286_ _2297_ _2298_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__nand3_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer17 _0675_ VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_6
Xrebuffer28 _0297_ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_60_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2955_ _2085_ _2086_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__a21oi_1
X_2886_ _2009_ _2016_ _2006_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__a21oi_1
X_4625_ _1297_ _1300_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__nor2_1
X_4556_ _1313_ _1302_ _1312_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nand3_1
X_3507_ _0202_ _0195_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout205_A net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4487_ _1235_ _1237_ _1203_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__nand3_4
X_3438_ _0064_ _0127_ _0137_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o211ai_4
X_3369_ _0067_ _2487_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout195_X net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4238__A2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5039_ clknet_3_7__leaf_clk _0055_ VGND VGND VPWR VPWR in1_reg\[7\] sky130_fd_sc_hd__dfxtp_4
XFILLER_25_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3921__A1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3921__B2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput42 net42 VGND VGND VPWR VPWR out[17] sky130_fd_sc_hd__buf_2
XANTENNA__3482__A in2_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput64 net64 VGND VGND VPWR VPWR out[8] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR out[27] sky130_fd_sc_hd__buf_2
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3437__B1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2740_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__inv_2
X_2671_ _1803_ _1804_ _1772_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__a21o_1
X_4410_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__inv_2
XFILLER_8_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4341_ _1072_ _1083_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and3_1
X_4272_ _1008_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__nand2_1
XANTENNA__4638__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3223_ net242 net123 VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__nand2_1
X_3154_ net171 net197 VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__and2_1
XFILLER_27_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3085_ _2212_ _2215_ _2211_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_37_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4640__A2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout155_A net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3987_ _0688_ _0701_ _0703_ _0700_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__o211ai_4
X_2938_ _2051_ _2039_ _2042_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__o21a_1
X_2869_ _1996_ _1999_ _1994_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__nand3b_2
X_4608_ _1374_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__nand2_1
X_4539_ _1296_ _1298_ net125 net184 VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__and4_2
XANTENNA__4548__D net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3667__B1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout68_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2945__A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer8 _0633_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA__4101__A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3362__D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2827__Y net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4890_ _1560_ _1562_ _1634_ _1632_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__a31o_1
X_3910_ _0624_ _0627_ _0617_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__o21bai_1
XFILLER_32_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3841_ _0475_ _0477_ net308 _0556_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__o2bb2ai_2
X_3772_ in2_reg\[5\] net108 VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__and2_1
XANTENNA__3189__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2723_ _1837_ _1838_ _1856_ _1857_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__o211a_2
XTAP_TAPCELL_ROW_42_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2654_ _1455_ _1789_ net254 net151 _1788_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__o2111ai_4
X_2585_ _1129_ _1347_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__or2_1
X_4324_ net125 net131 net195 net188 VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__nand4_1
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_2
Xfanout117 in1_reg\[10\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_12
Xfanout128 in1_reg\[8\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_4
X_4255_ _0945_ _0947_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__o21ai_2
XFILLER_47_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout139 net141 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_4186_ _0793_ _0914_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__nand2_2
X_3206_ net254 net116 VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout272_A _0592_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3137_ _2157_ _2161_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__nand2_1
XANTENNA__4074__B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3068_ net253 net121 _2195_ _2197_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__a22o_1
XFILLER_23_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2913__B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3888__B1 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4301__B2 _1034_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4301__A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3591__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4040_ _0734_ _0724_ _0717_ _0722_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4942_ _1727_ _1734_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__xor2_1
XANTENNA__3803__B1 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4873_ _1659_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__nor2_1
XFILLER_20_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4006__A net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3824_ _0494_ _0499_ _0500_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__nand3_2
XANTENNA__3031__A1 _1962_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3755_ _0461_ _0442_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2_2
X_3686_ _0382_ _0383_ _0386_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__and3_1
X_2706_ _1784_ _1790_ _1787_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout118_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2637_ net157 net250 VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__nand2_1
XANTENNA__2542__B1 net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2568_ net169 net250 net243 net173 VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__a22oi_1
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2499_ net235 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__inv_2
X_4307_ net73 _0515_ _0915_ _0919_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__o31a_1
XANTENNA__3580__A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4238_ net80 _0559_ _0967_ _0969_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__o22a_1
X_4169_ _0818_ _0853_ _0894_ _0852_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__o211ai_1
XFILLER_55_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2845__A1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4047__B1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5023__CLK clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3739__B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout90_X net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4038__B1 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2834__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4589__B2 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4471__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3540_ _2477_ _0114_ _0239_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand3_1
XFILLER_6_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3471_ _0427_ net74 _2316_ _2411_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__o22a_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4023_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__inv_2
XFILLER_64_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4925_ _1716_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nand2b_1
X_4856_ net298 _1551_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__o21a_1
XANTENNA_fanout235_A in2_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3807_ _0518_ _0519_ net126 net218 VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__and4_1
X_4787_ net100 net194 net94 net186 VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__nand4_1
X_3738_ net144 net203 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__and2_1
XFILLER_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3669_ _0417_ net72 _0131_ _0366_ _0365_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__o221ai_2
XTAP_TAPCELL_ROW_7_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3849__A3 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2690__C1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2971_ _2098_ _2100_ _2096_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__a21o_1
X_4710_ _1408_ _1405_ _1407_ _1441_ _1446_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__o2111ai_4
X_4641_ _1406_ _1408_ _1405_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__o21ai_1
X_4572_ _1332_ _1333_ _1295_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3523_ _0223_ _0178_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nand2_1
X_3454_ _0147_ _0148_ _0149_ _0072_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o2bb2ai_1
X_3385_ _0078_ _0083_ _2478_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21o_1
XFILLER_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4006_ net159 net177 VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__nand2_1
XFILLER_52_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4908_ _1677_ _1678_ _1676_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout238_X net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4839_ _1566_ _1579_ _1581_ _1622_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__nand4_1
XFILLER_4_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4864__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3464__B2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4104__A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3170_ net304 _2246_ _2299_ _2300_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__o211ai_2
XFILLER_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer18 _0670_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2954_ _1973_ net220 net166 _1974_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__a31o_1
X_2885_ _2012_ _2015_ net81 net77 VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__o2bb2ai_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4624_ _1339_ _1340_ _1362_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__o21ai_1
X_4555_ _1315_ _1307_ _1304_ _1316_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__o211ai_2
X_3506_ net82 _0537_ _2443_ _0200_ _0199_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__o221ai_4
X_4486_ _1044_ _1050_ _1240_ _1241_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__o211ai_4
X_3437_ _0133_ _0134_ _0406_ net72 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o2bb2ai_1
X_3368_ _0362_ net72 _2289_ _2489_ _0066_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__o221ai_4
XFILLER_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout188_X net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3299_ net236 net128 VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__nand2_1
X_5038_ clknet_3_4__leaf_clk _0054_ VGND VGND VPWR VPWR in1_reg\[6\] sky130_fd_sc_hd__dfxtp_4
XFILLER_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2654__C1 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput43 net43 VGND VGND VPWR VPWR out[18] sky130_fd_sc_hd__buf_2
XANTENNA__3921__A2 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput65 net65 VGND VGND VPWR VPWR out[9] sky130_fd_sc_hd__buf_2
Xoutput54 net54 VGND VGND VPWR VPWR out[28] sky130_fd_sc_hd__buf_2
XFILLER_0_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input30_A in2[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3437__B2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2670_ _1773_ _1800_ _1802_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__and3_1
XFILLER_8_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4340_ _1078_ _1080_ _0493_ net71 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__o2bb2ai_1
XANTENNA__3568__A1_N _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4271_ _1006_ _1005_ _1004_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__nand3_2
X_3222_ net243 net129 net121 net248 VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__a22oi_4
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3153_ _2240_ _2243_ _2241_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__a21oi_2
X_3084_ net248 net241 net130 net136 VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_37_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3986_ _0688_ _0701_ _0700_ _0703_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__o211a_4
XANTENNA_fanout148_A in1_reg\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2937_ _2051_ _2039_ _2042_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__o21ai_1
X_4607_ _1366_ _1367_ _1370_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nand3_1
X_2868_ _1996_ _1999_ net150 net237 VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__and4b_1
X_2799_ net81 _0449_ _1846_ _1928_ _1927_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__o221ai_4
X_4538_ net125 net184 _1296_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__a22oi_4
X_4469_ net119 net195 net188 net125 VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__a22oi_1
XANTENNA__3667__B2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3419__A1 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer9 _0338_ VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_input33_X net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3840_ _0546_ _0556_ net281 VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o21ai_2
X_3771_ _0297_ _0338_ _0333_ _0331_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_42_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2722_ _1856_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__nand2_2
XFILLER_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ net266 net260 net286 net141 VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nand4_4
X_2584_ _1325_ _1336_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__nand2_1
X_4323_ net125 net131 net195 net188 VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__and4_1
Xfanout118 net124 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_4
Xfanout107 net111 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_4
Xfanout129 net130 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_6
X_4254_ _0985_ _0987_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__nand2_1
X_4185_ net222 net102 net97 net228 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a22oi_4
X_3205_ _2193_ _2194_ _2197_ _2192_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__a22oi_2
X_3136_ _2263_ _2148_ _2262_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__nand3_2
X_3067_ _2195_ _2197_ _2191_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__a21oi_2
XANTENNA__4074__B2 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3969_ _0684_ _0680_ _0677_ _0685_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o211ai_2
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3888__B2 _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3463__D net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout80_A _0427_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4301__A2 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2551__A1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4941_ _1732_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__and2b_1
X_4872_ _1423_ _1573_ _1614_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__o21ai_2
XFILLER_32_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3823_ _0491_ _0492_ _0501_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o21ai_1
XANTENNA__4006__B net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3754_ _0440_ _0441_ _0458_ _0459_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__o211ai_2
X_2705_ _1837_ _1838_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__nor2_1
X_3685_ _0121_ _0123_ _0140_ _0385_ net309 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__o311a_1
X_2636_ _1553_ _1660_ _1542_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__a21boi_1
XANTENNA__4379__D net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2567_ _1075_ _1140_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__or2_1
X_4306_ _0916_ net110 net217 VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__and3_1
X_2498_ net143 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__inv_2
X_4237_ _0967_ _0969_ net143 net183 VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__o211a_1
XFILLER_59_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2845__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4168_ _0818_ _0853_ _0894_ _0852_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__o211a_1
XANTENNA_fanout268_X net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4047__B2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4099_ _0681_ _0684_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__nand2_1
XFILLER_55_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout170_X net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3119_ _2132_ _2128_ _2093_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2643__C net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4867__A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3013__A2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3665__B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3470_ _0169_ _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__nand2_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4022_ _0564_ _0613_ _0735_ _0736_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__o211ai_4
XANTENNA__4985__CLK clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4924_ _1713_ _1715_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4855_ _1544_ _1546_ _1599_ _1600_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__and4bb_1
X_4786_ net100 net193 net94 net187 VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__and4_1
XFILLER_20_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3806_ net126 net218 _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_50_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout130_A in1_reg\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3575__B net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3737_ _0360_ _0367_ _0364_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__a21oi_2
XANTENNA__3960__B1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3668_ _0367_ net202 net148 VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__nand3_1
X_3599_ _0192_ _0213_ _0209_ _0203_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__o2bb2ai_2
X_2619_ _1183_ _1314_ _1292_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_7_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3849__A4 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkload6_A clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2690__B1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2970_ _2098_ _2100_ _2096_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__a21oi_1
X_4640_ _0493_ _0559_ _1406_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__o22a_1
X_4571_ _1290_ _1291_ _1332_ _1333_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__o211ai_2
X_3522_ net320 _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nand2_1
X_3453_ _0074_ _2483_ _0073_ _0147_ _0148_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o2111ai_1
X_3384_ _0078_ _0083_ _2478_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4005_ _0717_ _0722_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout178_A in2_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4970__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4907_ _1684_ _1638_ _1647_ _1691_ _1681_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__o221ai_4
X_4838_ _1582_ _1621_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__nand2_1
X_4769_ _1549_ _1471_ _1548_ _1384_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__o22ai_4
XANTENNA__2649__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3216__A2 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4716__A2 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4104__B net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer19 _0670_ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_2
X_2953_ _2074_ _2082_ _2084_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__nand3b_2
XTAP_TAPCELL_ROW_60_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2884_ _1928_ _2010_ _2017_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__a21o_1
X_4623_ _1339_ _1340_ _1360_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__o21a_1
X_4554_ _1315_ _1307_ _1304_ _1316_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__o211a_2
X_3505_ _0196_ _0201_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nand2_1
X_4485_ _1044_ _1050_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__o21ai_2
X_3436_ _0133_ _0134_ net154 net202 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__nand4_2
XANTENNA__4340__B1 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3367_ _2289_ _2489_ net160 net202 _0066_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__o2111ai_2
X_3298_ _2349_ _2363_ _2351_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__a21boi_2
X_5037_ clknet_3_6__leaf_clk _0053_ VGND VGND VPWR VPWR in1_reg\[5\] sky130_fd_sc_hd__dfxtp_2
XFILLER_13_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput55 net55 VGND VGND VPWR VPWR out[29] sky130_fd_sc_hd__buf_2
Xoutput44 net44 VGND VGND VPWR VPWR out[19] sky130_fd_sc_hd__buf_2
XFILLER_0_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4875__A _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4882__A1 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in2[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_1__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ _1002_ _1003_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__nand3_2
XANTENNA__4322__B1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3221_ net236 net135 VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__nand2_1
X_3152_ _2190_ _2253_ _2256_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__o21ai_1
XFILLER_54_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3083_ _2097_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_37_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3985_ _0700_ _0702_ _0703_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a21o_4
X_2936_ _2062_ _1968_ _2068_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__o21ai_4
XFILLER_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2867_ _0417_ net78 _1996_ _1998_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__o22ai_4
X_4606_ _1368_ _1371_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nand2_1
X_2798_ _1846_ _1928_ _1924_ _1927_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__o211ai_2
X_4537_ net118 net113 net195 net188 VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__nand4_2
X_4468_ net131 net183 VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__and2_1
X_3419_ net159 net198 net192 net165 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__a22o_1
X_4399_ _1145_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3107__A1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_48_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2572__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3770_ _0331_ _0333_ _0338_ _0297_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a2bb2oi_2
XTAP_TAPCELL_ROW_42_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2721_ _1853_ _1842_ _1852_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_57_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2652_ net257 net141 VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__nand2_2
X_2583_ _1292_ _1314_ _1183_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nand3b_1
X_4322_ net125 net195 net188 net131 VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a22o_1
Xfanout119 net124 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_4
X_4253_ _0843_ _0834_ _0837_ _0983_ _0984_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__o2111ai_2
Xfanout108 net110 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_6
X_3204_ _2193_ _2194_ _2197_ _2192_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__a22o_1
X_4184_ net228 net97 VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_66_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3135_ _2262_ _2263_ _2146_ _2147_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_27_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3066_ _2193_ _2194_ _2196_ _2112_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_67_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout160_A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3968_ _0686_ _0687_ _0676_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__a21oi_2
XFILLER_50_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2919_ _2047_ _2048_ _2040_ _2042_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__o211ai_1
XANTENNA__3585__A1 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3899_ net246 net92 VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nand2_1
XANTENNA__3744__D net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout73_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3488__B net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3654__D net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2839__B1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4940_ _1730_ _1731_ net66 VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21o_1
X_4871_ _1656_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__and2b_1
X_3822_ _0532_ _0533_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__nand2_2
X_3753_ _0440_ _0441_ _0459_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o21ai_1
X_3684_ _0121_ _0123_ _0140_ net309 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__o31a_1
X_2704_ _1833_ _1835_ _1836_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__and3_1
X_2635_ _1542_ _1771_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__nand2_1
X_4305_ _1040_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__nand2_1
X_2566_ net169 net243 _1064_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__and3_1
X_2497_ net150 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkinv_4
X_4236_ _0965_ _0968_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__and3_1
XANTENNA__3580__C net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4167_ _0854_ _0893_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nand3_1
X_3118_ net310 _2226_ _2248_ _2225_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_2_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4098_ _0678_ _0680_ _0683_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__o21ai_2
XFILLER_70_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3049_ _2176_ _2178_ _2174_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2643__D net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4867__B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout76_X net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout90 in1_reg\[14\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_24_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4021_ _0565_ _0614_ _0738_ _0739_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nand4_1
XANTENNA__3485__B1 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4923_ _1713_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__nor2_1
X_4854_ _1638_ _1641_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4785_ net193 net94 net187 net100 VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__a22o_1
X_3805_ net229 net227 net120 net114 VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__nand4_4
XANTENNA__3856__B net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout123_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3736_ _0360_ _0367_ _0364_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21o_1
XANTENNA__4968__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3667_ _0365_ _0367_ _0417_ net72 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__o2bb2ai_1
X_3598_ _0190_ _0191_ _0203_ _0209_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o22a_1
X_2618_ _1183_ _1314_ _1292_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_7_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2549_ _0944_ _0955_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nand2_1
X_4219_ net210 net114 net204 net119 VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_58_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4967__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4719__B1 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4570_ _1330_ _1331_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__nand2_1
X_3521_ _0217_ _0210_ _0219_ _0181_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__o211ai_4
X_3452_ _0072_ _0149_ _0148_ _0147_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__o211a_1
X_3383_ _0078_ _0083_ _2478_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and3_1
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4004_ _0721_ _0616_ _0720_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__nand3_4
XFILLER_65_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4906_ _1684_ _1638_ _1647_ _1691_ _1681_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__o221a_1
XANTENNA_fanout240_A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4837_ _1569_ _1570_ _1582_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__and3_1
XANTENNA__2984__A2 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4768_ _1378_ _1376_ _1473_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__o21a_2
XANTENNA_fanout126_X net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4699_ _1376_ _1378_ _1388_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__o21ai_1
X_3719_ _0256_ _0258_ _0423_ net273 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a31o_1
XFILLER_56_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2952_ _2081_ _2083_ _2074_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__o21ai_4
X_2883_ _1928_ _2010_ _2008_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__o21ai_2
X_4622_ _1283_ _1364_ _1365_ _1366_ _1371_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a32o_1
X_4553_ _0515_ net71 _1307_ _1310_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__o22ai_2
X_4484_ _1220_ _1221_ _1234_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__nand3_2
X_3504_ _2443_ _0200_ _0195_ _0199_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__o211ai_2
X_3435_ _0406_ net72 _0133_ _0134_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__o211ai_2
XANTENNA__4340__B2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3366_ _0065_ _0066_ _0362_ net72 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_68_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3297_ _2363_ _2349_ _2344_ _2350_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__o2bb2ai_4
X_5036_ clknet_3_6__leaf_clk _0052_ VGND VGND VPWR VPWR in1_reg\[4\] sky130_fd_sc_hd__dfxtp_2
XANTENNA__4981__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout243_X net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4221__A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput34 net34 VGND VGND VPWR VPWR out[0] sky130_fd_sc_hd__buf_2
Xoutput56 net56 VGND VGND VPWR VPWR out[2] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR out[1] sky130_fd_sc_hd__buf_2
XANTENNA__4875__B net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4882__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input16_A in1[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2842__C net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4322__A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3220_ _2336_ _2345_ _2346_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__nand3_2
X_3151_ _2249_ _2252_ _2250_ _2189_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__a31oi_2
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3082_ net241 net130 VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__nand2_1
XFILLER_54_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3984_ _0700_ _0702_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a21oi_4
X_2935_ _2063_ _2066_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_20_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2866_ _0417_ net78 _1996_ _1998_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__o22a_1
X_4605_ _1366_ _1367_ _1371_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nand3_1
X_2797_ net81 _0449_ _1930_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__o21ai_1
X_4536_ net118 net113 net193 net187 VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__and4_1
X_4467_ _1220_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__nand2_1
XANTENNA__4976__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4398_ _1135_ _1139_ _1142_ _1138_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o211ai_1
X_3418_ net159 net165 net198 net191 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__nand4_2
XANTENNA_input8_A in1[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3349_ _2312_ _2320_ _2321_ _2326_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout193_X net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5026__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5019_ clknet_3_0__leaf_clk _0035_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfxtp_1
XFILLER_26_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2943__B net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2866__A1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3668__C net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3043__A1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2720_ _1847_ _1854_ _1843_ _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__o211ai_4
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2651_ _1785_ _1786_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__nand2_2
X_2582_ _1151_ _1172_ _1292_ _1303_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__o22ai_1
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4321_ net137 net183 VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nand2_1
X_4252_ _0837_ _0849_ _0983_ _0984_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a22o_1
Xfanout109 net111 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_2
X_3203_ _2207_ _2219_ _2209_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__a21boi_1
X_4183_ net217 net110 VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nand2_2
XFILLER_67_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3134_ _2146_ _2147_ _2262_ _2263_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__o211ai_1
X_3065_ net262 net257 net116 net109 VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__nand4_4
XANTENNA_fanout153_A net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3967_ _0447_ _0682_ net138 net203 _0681_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__o2111ai_4
X_2918_ _2039_ _2041_ _2050_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__o21ai_1
X_3898_ net235 net102 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand2_1
XFILLER_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2849_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout206_X net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4519_ _1277_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__nand2_1
XANTENNA__4298__B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2497__Y _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4470__B1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2839__B2 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4870_ _1653_ _1655_ net95 net182 VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__nand4_2
X_3821_ _0535_ _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_30_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3752_ _0458_ _0459_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
X_2703_ _1835_ _1836_ _1833_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__a21oi_1
X_3683_ _0126_ _0140_ net309 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__o21ai_2
X_2634_ _1553_ _1660_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__nand2_1
X_2565_ net168 net243 VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__nand2_1
X_4304_ _0906_ _1041_ _1043_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nand3_4
X_2496_ net153 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__inv_2
XFILLER_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4235_ net132 net196 net189 net137 VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__a22o_1
X_4166_ _0845_ _0849_ _0820_ _0819_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a31o_1
X_3117_ _2227_ _2225_ _2245_ _2247_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__o2bb2ai_4
XANTENNA_fanout270_A _0592_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4097_ _0655_ _0653_ _0647_ _0651_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3048_ _2174_ _2176_ _2178_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout156_X net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4999_ clknet_3_0__leaf_clk _0015_ VGND VGND VPWR VPWR in2_reg\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4867__C net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3499__B net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout80 _0427_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_4
Xfanout91 net93 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_4
XFILLER_13_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3962__B net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4020_ _0565_ _0614_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nand3_4
XANTENNA__3485__A1 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4922_ _1667_ _1664_ _1666_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__a21boi_1
XFILLER_45_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4853_ _1636_ _1632_ _1598_ _1591_ _1635_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__o2111ai_2
XFILLER_20_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4784_ _1497_ _1510_ _1508_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__o21ai_1
X_3804_ _0514_ _0516_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand2_2
X_3735_ _0440_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nor2_1
X_3666_ net144 net140 net322 net209 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__nand4_4
XANTENNA_fanout116_A net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3597_ _0296_ _0289_ _0295_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__o21ai_4
X_2617_ _1542_ _1553_ _1660_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_7_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2548_ net266 net157 VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand2_1
X_4218_ net210 net114 VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand2_2
XFILLER_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout273_X net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4149_ _0760_ _0873_ _0874_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__nand3_2
XFILLER_55_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3228__A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3887__X _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload0 clknet_3_1__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_1
XFILLER_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout270 _0592_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4719__B2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3973__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3520_ _0215_ _0216_ _0180_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nand3_4
X_3451_ _0072_ _0149_ _0148_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o21ai_1
XANTENNA__2589__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3382_ _0083_ _2478_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__nand2_1
X_4003_ _0615_ _0719_ _0718_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand3_4
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4905_ _1555_ _1693_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout233_A in2_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4836_ _1567_ net180 net106 _1568_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__a31o_1
XANTENNA__4979__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4767_ _1379_ _1381_ _1472_ _1473_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__nand4_4
XFILLER_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4698_ _1468_ _1389_ _1467_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout119_X net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3718_ _0256_ _0258_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2499__A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3649_ _0170_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nand2_1
XFILLER_29_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2951_ _0362_ net74 _2079_ _2080_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__o211ai_1
XFILLER_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4621_ _1283_ _1364_ _1365_ _1366_ _1371_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__a32oi_2
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2882_ _2012_ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__nand2_1
X_4552_ _1311_ net200 net107 VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__nand3_1
X_4483_ _1222_ _1233_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__nand2_1
X_3503_ net252 net104 _0199_ _0201_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a22o_1
X_3434_ _0133_ _0134_ _0130_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a21o_1
X_3365_ _2289_ _2489_ _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_68_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3296_ _2423_ _2425_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__nand2_2
X_5035_ clknet_3_3__leaf_clk _0051_ VGND VGND VPWR VPWR in1_reg\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout183_A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4819_ net268 _1602_ _1603_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and3_1
XANTENNA__3367__B1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput35 net35 VGND VGND VPWR VPWR out[10] sky130_fd_sc_hd__buf_2
Xoutput46 net46 VGND VGND VPWR VPWR out[20] sky130_fd_sc_hd__buf_2
Xoutput57 net57 VGND VGND VPWR VPWR out[30] sky130_fd_sc_hd__buf_2
XANTENNA_fanout96_A in1_reg\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2842__D net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3070__A2 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA__4412__A net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4322__A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3150_ _2263_ _2148_ _2261_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__a21oi_4
X_3081_ net248 net130 net136 net241 VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3983_ _0531_ _0525_ _0527_ _0521_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o2bb2ai_4
X_2934_ _1965_ _1968_ _2064_ _2067_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_20_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2865_ net249 net242 net145 net139 VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__nand4_2
X_4604_ _1366_ _1367_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4535_ net113 net195 net188 net118 VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a22o_1
X_2796_ _1927_ _1929_ _1924_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__a21oi_2
X_4466_ _1215_ _1217_ _1204_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__nand3_4
X_4397_ _1138_ _1141_ _1142_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__and3_1
X_3417_ net159 net191 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nand2_1
X_3348_ _2285_ _2298_ _2297_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__a21bo_1
XANTENNA__4077__A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3279_ _2352_ _2356_ _2353_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5018_ clknet_3_0__leaf_clk _0034_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2687__A in1_reg\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2866__A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4407__A _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2650_ net257 net286 net141 net262 VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__a22oi_4
X_2581_ _1271_ _1282_ _1205_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__nand3_1
X_4320_ _1059_ _1060_ _0936_ _0939_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__o2bb2ai_4
X_4251_ _0949_ _0983_ _0984_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__nand3_1
X_3202_ _2219_ _2207_ _2199_ _2208_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__o2bb2ai_2
X_4182_ _0774_ _0775_ _0778_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__o21a_1
X_3133_ _2264_ _2148_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__nand2_1
XFILLER_67_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3806__A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3064_ net257 net109 VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_33_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3966_ _0681_ _0683_ _0449_ net71 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__o2bb2ai_2
X_2917_ _2047_ _2049_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__nand2b_1
XANTENNA__3585__A3 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3875__B net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3897_ _0200_ net87 net313 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__and3_1
X_2848_ _1915_ _1976_ _1977_ _1980_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__nand4_4
X_2779_ net248 net146 VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__nand2_1
X_4518_ _1166_ _1274_ _1275_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__nand3_4
X_4449_ _1070_ _1088_ _1085_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__a21oi_2
XANTENNA__4298__B2 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4470__B2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4470__A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3488__D net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2784__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2536__A1 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2839__A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2864__B net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3820_ _0281_ _0277_ _0280_ _0525_ _0528_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__o2111ai_2
XFILLER_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3751_ _0454_ _0443_ _0453_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nand3_2
X_2702_ _1835_ _1836_ net163 net238 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__and4_1
XFILLER_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3682_ _0382_ _0383_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nand2_2
X_2633_ _1767_ _1769_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__nand2_1
X_2564_ _1053_ _1075_ _1042_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__o21a_1
X_4303_ _0622_ _0904_ _1038_ _1037_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a2bb2oi_4
X_2495_ net173 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__inv_2
X_4234_ net132 net196 net189 net137 VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a22oi_4
X_4165_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__inv_2
X_3116_ _2242_ _2246_ _2245_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__a21oi_2
XFILLER_67_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4096_ _0690_ _0702_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
XFILLER_70_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3047_ _0395_ net72 _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__o21a_1
X_4998_ clknet_3_2__leaf_clk _0014_ VGND VGND VPWR VPWR in2_reg\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3949_ _0657_ _0659_ _0633_ _0635_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o211a_4
XFILLER_2_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4691__A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout92 net93 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_8
Xfanout70 _0581_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_4
Xfanout81 _0384_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_4
XANTENNA__5039__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4921_ _1674_ _1711_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__xor2_1
X_4852_ _1638_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__inv_2
X_3803_ net223 net120 net117 net229 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_15_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4783_ net112 net178 _1560_ _1561_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a22o_1
X_3734_ _0351_ _0436_ net161 net182 _0435_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__o2111a_1
X_3665_ net140 net209 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand2_1
X_2616_ _1542_ _1553_ _1660_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout109_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3596_ _0284_ _0292_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_7_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2547_ net162 net260 VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__nand2_1
X_4217_ net126 net200 VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand2_1
XFILLER_68_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4148_ _0871_ _0872_ _0759_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a21oi_2
XFILLER_55_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4079_ _0799_ _0788_ _0798_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__and3_1
XANTENNA__3228__A2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload1 clknet_3_2__leaf_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_50_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3164__A1 net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout260 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_4
XFILLER_59_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3973__B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3450_ _0074_ _0080_ _0147_ _0148_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a2bb2oi_2
X_3381_ _0081_ _0074_ _2480_ _0082_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__o211ai_2
XFILLER_69_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4002_ _0480_ _0551_ _0558_ _0719_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__o211ai_2
X_4904_ _1157_ _1554_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_63_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4835_ _1567_ net180 net106 _1568_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a31oi_1
XANTENNA__3586__D net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4766_ _1544_ _1546_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout226_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4591__B1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3717_ _0421_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nand2_1
X_4697_ _1391_ _1469_ _1470_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__nand3_2
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3648_ _0169_ _0173_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nand2_1
X_3579_ net230 net127 net224 net123 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__and4_1
XFILLER_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2950_ _0362_ net74 _2079_ _2080_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__o211a_1
XFILLER_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2881_ net263 net258 net129 net122 VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__nand4_2
X_4620_ _1387_ _1386_ net268 _1388_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o211a_1
X_4551_ _1308_ _1311_ _1305_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__a21o_1
X_4482_ _1220_ _1221_ _1234_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__a21oi_2
X_3502_ _0199_ _0201_ _0195_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a21oi_4
X_3433_ net149 net144 net213 net207 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__nand4_4
X_3364_ _2490_ _2491_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_68_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3295_ _2420_ _2421_ _2422_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__nand3_1
XANTENNA__3224__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5034_ clknet_3_3__leaf_clk _0050_ VGND VGND VPWR VPWR in1_reg\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout176_A net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2782__B net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4818_ _1545_ _1557_ _1601_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__a21o_1
XFILLER_21_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4749_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__inv_2
Xoutput36 net36 VGND VGND VPWR VPWR out[11] sky130_fd_sc_hd__buf_2
Xoutput47 net47 VGND VGND VPWR VPWR out[21] sky130_fd_sc_hd__buf_2
Xoutput58 net58 VGND VGND VPWR VPWR out[31] sky130_fd_sc_hd__buf_2
XFILLER_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout89_A net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3080_ net248 net130 net136 net241 VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__a22oi_2
XANTENNA__5032__Q in1_reg\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3982_ _0699_ _0690_ _0689_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand3_2
XFILLER_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2933_ net274 _2065_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__or3_1
XFILLER_50_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2864_ net249 net242 net145 net139 VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__and4_1
X_4603_ _1370_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__inv_2
X_2795_ _1849_ _1926_ _1928_ _1846_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__o2bb2ai_1
X_4534_ _1290_ _1291_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__or2_1
X_4465_ _1206_ _1218_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nand3_4
X_4396_ _1138_ _1141_ _1142_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a21o_1
X_3416_ _2420_ _2422_ _2421_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a21boi_2
X_3347_ _2332_ _2368_ _2370_ _2473_ _2472_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__o2111ai_4
XANTENNA__4077__A2 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3889__A _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5017_ clknet_3_0__leaf_clk _0033_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfxtp_1
X_3278_ _2352_ _2356_ _2353_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout179_X net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4785__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4232__B net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in2[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4407__B _0607_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4240__A2 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4528__B1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _1271_ _1282_ _1205_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_26_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4250_ _0949_ _0983_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nand2_1
X_4181_ _0774_ _0775_ _0778_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__o21ai_1
X_3201_ _2328_ _2327_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nand2_2
X_3132_ _2262_ _2263_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__nand2_1
X_3063_ _2193_ _2194_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__nand2_1
XFILLER_50_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3965_ _0681_ _0683_ _0678_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__a21o_1
XFILLER_50_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2916_ _2047_ _2048_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__nor2_1
X_3896_ _0546_ _0556_ _0555_ _0478_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a2bb2oi_2
XANTENNA__3875__C net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout139_A net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2847_ _1915_ _1980_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__nand2_1
X_2778_ net151 net242 VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nand2_1
X_4517_ _1274_ _1275_ _1166_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a21o_1
X_4448_ _1070_ _1088_ _1085_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a21o_1
X_4379_ _1124_ net142 _1122_ net179 VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nand4_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4470__A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3733__A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3750_ _0455_ _0448_ _0444_ _0456_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__o211ai_2
XFILLER_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2701_ net162 net238 _1835_ _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__a22oi_4
X_3681_ _0378_ _0349_ _0377_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nand3_2
X_2632_ _1596_ _1639_ net173 net233 VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__o211ai_4
X_2563_ _0880_ _1086_ _1108_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__o21a_1
X_4302_ _1032_ _1035_ _1029_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21o_1
XFILLER_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4233_ net137 net132 net196 net189 VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__nand4_2
X_2494_ net252 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__inv_2
X_4164_ _0692_ _0838_ _0841_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__o21ai_1
X_4095_ _0688_ _0697_ _0698_ _0690_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__o31a_1
X_3115_ _2240_ _2242_ _2243_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__and3_1
X_3046_ net160 net166 net214 net208 VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__nand4_2
XANTENNA__2790__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4997_ clknet_3_2__leaf_clk _0013_ VGND VGND VPWR VPWR in2_reg\[13\] sky130_fd_sc_hd__dfxtp_1
X_3948_ _0633_ _0635_ _0661_ _0663_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__o2bb2ai_4
X_3879_ _0267_ _0261_ _0264_ _0594_ _0591_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o2111ai_2
XANTENNA__3407__A net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout71_A _0526_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout71 _0526_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_8
Xfanout82 _0384_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__buf_4
Xfanout93 in1_reg\[14\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_6
XFILLER_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4920_ _1668_ _1711_ _1669_ _1663_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__and4_1
XANTENNA__5040__Q in1_reg\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4851_ _1591_ _1598_ _1635_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a22o_2
X_3802_ net228 net114 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand2_4
X_4782_ net112 net176 _1560_ _1561_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__a22oi_1
XFILLER_9_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3733_ net161 net184 _0435_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__a22oi_4
X_3664_ _0361_ _0363_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nand2_1
X_2615_ _1660_ _1553_ _1542_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__nand3b_1
X_3595_ _0284_ _0290_ _0291_ _0162_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_7_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2546_ net162 net266 net260 net157 VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand4_2
X_4216_ _0843_ _0834_ _0837_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__o21ai_2
X_4147_ _0872_ _0759_ _0871_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nand3_4
X_4078_ _0792_ _0794_ _0790_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a21o_1
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3029_ _2157_ _2159_ _2043_ _2045_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout161_X net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3936__A1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload2 clknet_3_3__leaf_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_2
XFILLER_50_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout272 _0592_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_fanout74_X net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout261 in2_reg\[1\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_6
XFILLER_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5006__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_4__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3380_ _0073_ _0075_ _2483_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__a21o_1
XFILLER_69_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5035__Q in1_reg\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4001_ _0673_ net291 _0713_ _0715_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__nand4_4
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4903_ _1550_ _1551_ _1643_ _1690_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_63_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4834_ _1618_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__or2_1
X_4765_ _1459_ _1478_ _1540_ _1541_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a22oi_1
X_3716_ _0418_ _0420_ _0253_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__a21bo_1
X_4696_ _1391_ _1469_ _1470_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__and3_2
XANTENNA_fanout219_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3647_ _0220_ _0227_ _0344_ _0342_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__o211ai_4
X_3578_ _0275_ _0276_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__nand2_2
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2529_ net267 net23 VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__and2_1
XANTENNA__5029__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2880_ net263 net258 net130 net122 VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_60_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4550_ _0515_ net71 _1209_ _1309_ _1308_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__o221ai_4
X_4481_ _1220_ _1221_ _1230_ _1232_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__nand4_2
X_3501_ _0199_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__nand2_1
XANTENNA__4325__A1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3432_ _2489_ _0131_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__nand2_2
X_3363_ net154 net149 net213 net207 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_68_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _2420_ _2422_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__nand2_1
X_5033_ clknet_3_3__leaf_clk _0049_ VGND VGND VPWR VPWR in1_reg\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_38_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout169_A in1_reg\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2782__C net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4817_ _1543_ _1479_ _1601_ _1557_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__o211ai_1
XFILLER_21_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4748_ _1524_ _1525_ _1450_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__o21ai_2
XANTENNA_fanout124_X net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4679_ _1337_ _1451_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput37 net37 VGND VGND VPWR VPWR out[12] sky130_fd_sc_hd__buf_2
Xoutput48 net48 VGND VGND VPWR VPWR out[22] sky130_fd_sc_hd__buf_2
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput59 net59 VGND VGND VPWR VPWR out[3] sky130_fd_sc_hd__buf_2
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4307__A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4858__A2 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2500__Y _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3981_ _0699_ _0690_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nand2_1
X_2932_ _1882_ _2059_ _1965_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_20_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2863_ net241 net139 VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__nand2_1
X_4602_ _1169_ _1175_ _1174_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__a21bo_1
X_2794_ net263 net258 net130 net135 VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__nand4_4
X_4533_ _1290_ _1291_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__nor2_1
XFILLER_7_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4464_ _1214_ _1207_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__nand2_1
X_4395_ _1138_ _1141_ _1142_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__a21oi_1
X_3415_ _2421_ _2424_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__nand2_1
X_3346_ _2407_ _2475_ _2474_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__nand3_4
XANTENNA__3889__B net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5016_ clknet_3_0__leaf_clk _0032_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfxtp_1
X_3277_ _2368_ _2332_ _2370_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__o21ai_2
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4785__A1 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2687__C net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in1[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4528__B2 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4528__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2597__C net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4180_ _0774_ _0778_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nand2_1
X_3200_ _2329_ _2330_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__nand2_1
X_3131_ _2259_ _2173_ _2260_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__nand3_4
X_3062_ net262 net109 VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__nand2_4
XFILLER_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3964_ _0451_ _0679_ _0678_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__o21ai_1
X_2915_ net172 net215 _2045_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__a21o_1
X_3895_ net308 _0556_ _0479_ _0554_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o22ai_2
X_2846_ _0406_ net78 _1917_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__o21ai_2
X_2777_ net158 net237 VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__and2_1
X_4516_ _1274_ _1275_ _1166_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__a21oi_2
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout201_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4447_ _0904_ _1198_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21ai_1
X_4378_ _1122_ _1124_ net80 net69 VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__o2bb2ai_1
XANTENNA_input6_A in1[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout191_X net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3329_ _2454_ _2441_ _2453_ VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__nand3_4
XFILLER_73_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4758__A1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3733__A2 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2700_ net157 net250 net152 net243 VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__nand4_4
X_3680_ _0380_ _0372_ _0350_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__o211ai_4
X_2631_ _1596_ _1639_ net174 net233 VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__o211a_1
XANTENNA__5038__Q in1_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2562_ _0880_ _1086_ net274 VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4301_ net73 _0537_ _0914_ _1034_ _1032_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o221ai_4
X_4232_ net138 net132 net196 net189 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__and4_1
X_2493_ net166 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__clkinv_4
XFILLER_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4163_ net267 _0890_ _0892_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__and3_1
X_4094_ _0773_ _0813_ _0815_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand3_2
X_3114_ _2238_ _2239_ _2228_ _2244_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__a31oi_2
X_3045_ net160 net207 VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout151_A net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4996_ clknet_3_2__leaf_clk _0012_ VGND VGND VPWR VPWR in2_reg\[12\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout249_A net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3947_ _0633_ _0635_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__a21oi_2
X_3878_ _0265_ _0596_ _0594_ _0591_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__o211ai_2
X_2829_ _1882_ _1887_ _1963_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_18_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout83 net85 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_52_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout72 _0526_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_54_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout94 net95 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_2
XFILLER_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4903__A1 net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4435__Y _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4850_ _1560_ _1562_ _1633_ _1634_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_72_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3801_ net224 net120 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2_1
X_4781_ _1560_ _1561_ net112 net178 VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__nand4_4
XFILLER_60_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3732_ net153 in1_reg\[4\] net197 net191 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nand4_2
X_3663_ net140 net211 net209 net144 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a22oi_4
X_2614_ _1563_ _1660_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__nand2_1
X_3594_ _0162_ _0291_ _0290_ _0284_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__o211a_1
X_2545_ net260 net157 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
X_4215_ _0936_ _0939_ _0943_ _0938_ _0785_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__o2111ai_4
X_4146_ _0867_ _0870_ _0768_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a21o_1
X_4077_ net73 _0504_ _0640_ _0793_ _0792_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o221ai_2
X_3028_ _2159_ _2047_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__nand2_1
XFILLER_43_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout154_X net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4979_ net267 net3 VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__and2_1
XANTENNA__3936__A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload3 clknet_3_4__leaf_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_4
XANTENNA__3916__A1_N _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3418__A net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout240 net244 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_6
XFILLER_59_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout273 net33 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_3_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout262 net263 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_8
Xfanout251 in2_reg\[3\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_4
XFILLER_19_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3303__D net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4000_ net291 _0673_ _0712_ _0714_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4902_ _1550_ _1551_ _1643_ _1690_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_63_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4833_ _1578_ _1580_ _1613_ _1614_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__and4_1
XFILLER_60_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4764_ _1479_ _1543_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__or2_1
X_3715_ _0253_ _0418_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__nand3b_4
X_4695_ _1459_ _1462_ _1464_ _1351_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__o2bb2ai_1
XANTENNA_fanout114_A net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3646_ net305 _0339_ _0220_ _0227_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__o2bb2ai_4
X_3577_ net127 net227 net123 net230 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a22oi_4
X_2528_ net269 net22 VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and2_1
XFILLER_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout271_X net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4129_ _0852_ _0854_ _0819_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a21oi_1
XFILLER_16_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3420__B net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3148__A net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3500_ net265 net261 net98 net92 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__nand4_4
XFILLER_51_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4480_ _1233_ _1220_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nand2_1
XANTENNA__4325__A2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5046__Q in1_reg\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3431_ net144 net213 net209 net149 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a22oi_1
X_3362_ net154 net149 net213 net207 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_68_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ _2420_ _2421_ _2422_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__a21o_1
X_5032_ clknet_3_3__leaf_clk _0048_ VGND VGND VPWR VPWR in1_reg\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4816_ _1599_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__nand2_1
XFILLER_21_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout231_A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4747_ _1521_ _1522_ _1449_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21ai_2
X_4678_ _1285_ _1033_ _1447_ _1445_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__o22ai_2
XANTENNA_fanout117_X net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3629_ _0327_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__nand2_2
Xoutput38 net38 VGND VGND VPWR VPWR out[13] sky130_fd_sc_hd__buf_2
Xoutput49 net49 VGND VGND VPWR VPWR out[23] sky130_fd_sc_hd__buf_2
XFILLER_0_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4527__A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4307__A2 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2510__A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3980_ _0689_ _0690_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a21o_4
X_2931_ _1968_ _2062_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__nor2_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_4601_ _1366_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__nand2_1
X_2862_ net242 net145 net139 net249 VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__a22oi_4
X_2793_ net258 net129 VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__nand2_4
X_4532_ _1291_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__inv_2
XFILLER_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4463_ _0504_ net71 _1076_ _1212_ _1211_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__o221ai_4
X_3414_ _2477_ _0114_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ _1142_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__inv_2
X_3345_ _2423_ _2425_ _2469_ _2470_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__a22o_1
X_3276_ _2376_ _2381_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__nand2_1
X_5015_ clknet_3_2__leaf_clk _0031_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout181_A net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4234__A1 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2687__D net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3161__A net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4528__A2 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2511__Y _0570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3130_ _2258_ _2172_ _2257_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__nand3_2
X_3061_ net257 net116 VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3963_ net127 net133 net211 net205 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__nand4_2
X_2914_ _1900_ _1903_ _2044_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__and3_1
XFILLER_31_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3894_ _0582_ _0583_ _0566_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__o21ai_2
X_2845_ _0373_ net74 _1973_ _1975_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__o211ai_1
X_2776_ _1856_ _1908_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__nand2_1
X_4515_ _1269_ _1270_ _1273_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__nand3_2
X_4446_ _1057_ _1055_ _1193_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__a21o_1
XANTENNA__2950__A1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4377_ _0969_ _0965_ _0968_ _0984_ _0986_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__o2111ai_4
X_3328_ _2457_ VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout184_X net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3259_ _2186_ _2185_ _2385_ _2384_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__o211ai_2
XANTENNA__4758__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3966__B1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2506__Y _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ net174 net233 _1596_ _1639_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__a211o_2
X_2561_ _0880_ _1086_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__and2_1
X_4300_ _1038_ _0905_ _1037_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nand3_4
X_2492_ net162 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__inv_2
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4231_ net142 net183 VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4162_ _0889_ _0886_ _0884_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a21o_1
X_4093_ net282 net293 _0811_ _0812_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nand4_4
X_3113_ _2242_ _2240_ _2243_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__a21oi_4
X_3044_ net160 net214 net207 net166 VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__a22o_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4995_ clknet_3_2__leaf_clk _0011_ VGND VGND VPWR VPWR in2_reg\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3946_ _0658_ _0660_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__nand2_1
X_3877_ _0591_ _0594_ _0595_ _0267_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__o2bb2ai_2
X_2828_ _1961_ _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__nand2_1
X_2759_ net163 net168 net232 net227 VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__nand4_4
X_4429_ _0449_ net69 _1174_ _1175_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__o211ai_2
XFILLER_58_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout73 net76 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_52_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout95 net96 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_2
Xfanout84 net85 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4780_ _1519_ _1517_ _1515_ _1559_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__o211ai_4
X_3800_ net126 net218 VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__nand2_1
XFILLER_20_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3731_ net153 net148 net197 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__and3_1
X_3662_ net140 net211 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand2_1
X_3593_ _0160_ _0161_ _0284_ _0290_ _0291_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__a221oi_2
X_2613_ _1606_ _1639_ _1650_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__a21oi_2
X_2544_ _0836_ _0825_ _0814_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__o21ai_1
X_4214_ _0784_ _0942_ _0941_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a21oi_2
X_4145_ _0867_ _0870_ _0768_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__nand3_1
X_4076_ _0640_ _0793_ net218 net114 _0792_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__o2111ai_2
X_3027_ _2157_ _2159_ _2044_ _2046_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_66_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4978_ net268 net2 VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and2_1
XFILLER_51_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3929_ net76 _0493_ _0516_ _0643_ _0642_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__o221ai_4
Xclkload4 clknet_3_5__leaf_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout230 in2_reg\[6\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_6
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_6
Xfanout274 net33 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_2
Xfanout252 net256 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__buf_6
Xfanout263 in2_reg\[0\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_4
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3388__A1 _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2513__A net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4888__A1 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4175__A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4901_ _1642_ _1686_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__or2_1
X_4832_ _1578_ _1580_ _1613_ _1614_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__a22oi_1
X_4763_ _1479_ _1543_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__nor2_2
X_4694_ _1354_ _1353_ _1350_ _1462_ _1459_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__o2111ai_2
X_3714_ _0416_ _0245_ _0411_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand3_4
X_3645_ _0334_ _0340_ _0341_ _0272_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__o211ai_4
XANTENNA_fanout107_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3576_ net230 net123 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__nand2_1
X_2527_ net269 net21 VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and2_1
XFILLER_68_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4128_ _0844_ _0848_ _0820_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o21bai_2
X_4059_ _0774_ _0776_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__and3_1
XANTENNA__3420__C net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2508__A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3430_ net144 net215 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__nand2_1
XANTENNA__3533__B2 _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3361_ net149 net213 VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5031_ clknet_3_0__leaf_clk _0047_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfxtp_1
X_3292_ _2315_ net219 net149 _2317_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__a31o_1
XANTENNA__4336__C net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4815_ _1536_ _1540_ _1595_ _1597_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__nand4_2
X_4746_ _1515_ _1518_ _1519_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__a21boi_1
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout224_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4677_ _1448_ _1404_ _1446_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__nand3_2
X_3628_ _0323_ _0325_ _0313_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__nand3_4
Xoutput39 net39 VGND VGND VPWR VPWR out[14] sky130_fd_sc_hd__buf_2
X_3559_ _0115_ _0234_ _0235_ _0248_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a31oi_2
XANTENNA__4527__B _0570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4437__B _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2509__Y _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2930_ _1966_ _2062_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__a21o_1
XFILLER_62_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4600_ _1365_ _1283_ _1364_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nand3_1
X_2861_ net150 net237 VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__nand2_1
X_2792_ _1849_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__nand2_2
X_4531_ _1286_ _1288_ _1289_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__nor3_4
XFILLER_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4462_ _1076_ _1212_ net113 net200 _1211_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__o2111ai_4
X_3413_ _0085_ _0086_ _2476_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__o21ai_1
X_4393_ _0417_ net70 _0897_ _0896_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__o31a_1
X_3344_ _2423_ _2425_ _2469_ _2470_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__nand4_1
X_3275_ _2310_ _2374_ _2375_ _2309_ _2377_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__a32oi_2
X_5014_ clknet_3_3__leaf_clk _0030_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout227_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4729_ net201 net94 _1502_ _1504_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__a22o_1
XANTENNA__3745__A1 _0427_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout87_A in1_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3161__B net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2711__A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3060_ net253 net121 VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__nand2_1
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3962_ net127 net205 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2913_ net172 net215 _2045_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__and3_1
X_3893_ _0562_ _0428_ _0563_ _0584_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a31oi_2
X_2844_ _1972_ _1974_ net166 net219 VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_41_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4514_ _1269_ _1270_ _1272_ _1123_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o2bb2ai_2
X_2775_ _1857_ _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__nand2_1
X_4445_ _1055_ _1056_ _1193_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__nand3_2
XANTENNA__2950__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4376_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__inv_2
X_3327_ _2342_ _2440_ _2450_ _2451_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__o211ai_4
XFILLER_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3258_ _2384_ _2385_ _2188_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout177_X net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3663__B1 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3189_ _0417_ net74 _2318_ _2319_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__o211ai_2
XFILLER_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3966__B2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4915__B1 _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5009__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2516__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4382__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2560_ _1053_ _1064_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__xnor2_1
X_4230_ _0958_ _0959_ _0960_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nand3_4
XFILLER_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4161_ _0884_ _0889_ _0886_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand3_1
XFILLER_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4092_ _0809_ _0810_ _0786_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a21o_1
X_3112_ _0362_ net75 _2078_ _2080_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__o31a_1
X_3043_ net160 net213 net208 net166 VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__a22oi_2
X_4994_ clknet_3_2__leaf_clk _0010_ VGND VGND VPWR VPWR in2_reg\[10\] sky130_fd_sc_hd__dfxtp_2
X_3945_ _0662_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__nand2_1
X_3876_ net170 net177 _0266_ _0265_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a31o_1
X_2827_ _1875_ _1957_ _1960_ _1958_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__nand4_4
X_2758_ _1822_ _1892_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__nand2_1
X_2689_ _1823_ _1824_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__or2_1
X_4428_ _1176_ _1169_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nand2_1
XFILLER_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4359_ _1096_ _1098_ _1101_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__and3_1
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4061__B1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout74 net76 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_52_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout96 in1_reg\[13\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_6
Xfanout85 in1_reg\[15\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
XFILLER_13_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4994__Q in2_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4726__A net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3730_ net148 net190 VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nand2_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3661_ net144 net209 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__nand2_1
X_3592_ _0159_ _0162_ _0164_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__o21ai_2
X_2612_ _0395_ net78 _1606_ _1628_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2543_ _0782_ _0869_ _0891_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__a21oi_1
X_4213_ _0938_ _0940_ _0943_ _0785_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a22o_4
X_4144_ _0766_ _0767_ _0870_ _0867_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__a22o_4
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4075_ _0792_ _0794_ net218 net114 VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__and4_1
XANTENNA__3540__A _2477_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3026_ _2071_ _2153_ _2154_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_66_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4977_ net267 net16 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__and2_1
Xclkload5 clknet_3_6__leaf_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__bufinv_16
X_3928_ net76 _0493_ _0645_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__o21ai_2
X_3859_ _0569_ _0572_ _0575_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__and3_1
XFILLER_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout231 net232 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_8
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_2
Xfanout264 net266 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_6
XANTENNA__3321__A2 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout253 net255 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout242 net244 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_8
XANTENNA__3388__A2 net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4989__Q in2_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4337__A1 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4888__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3360__A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4900_ _1642_ _1686_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__nor2_1
X_4831_ _1615_ _1614_ _1613_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__nand3_1
X_4762_ _1540_ _1541_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__nand2_1
XFILLER_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4693_ _1463_ _1465_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__nand2_1
X_3713_ _0411_ _0245_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand2_1
X_3644_ _0296_ _0289_ _0295_ net280 net317 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o2111ai_4
X_3575_ net127 net224 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__nand2_1
X_2526_ net267 net20 VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__and2_1
XFILLER_56_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4127_ _0845_ _0849_ _0820_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a21oi_1
X_4058_ net246 net240 net91 net86 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__nand4_2
XFILLER_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3009_ _2032_ _2072_ _2137_ _2138_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__o211ai_4
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout72_X net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4007__B1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2524__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3360_ net154 net207 VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__nand2_1
X_5030_ clknet_3_0__leaf_clk _0046_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfxtp_1
X_3291_ _2409_ _2416_ _2417_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_68_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4336__D net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4814_ _1536_ _1540_ _1595_ _1597_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__a22o_1
X_4745_ _1429_ _1434_ _1515_ _1518_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__o211a_1
X_4676_ _1448_ _1404_ _1446_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__and3_2
X_3627_ _0321_ _0317_ _0314_ _0322_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o211ai_4
X_3558_ net269 _0257_ _0258_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__and3_1
X_2509_ net95 VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__inv_2
X_3489_ _0187_ _0189_ _0182_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__a21oi_4
XFILLER_56_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4527__C _1034_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4824__A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2519__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2860_ _0417_ net78 VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__nor2_1
X_2791_ net263 net129 VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__nand2_4
X_4530_ _1185_ _1184_ _1288_ _1286_ _1187_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__o221a_1
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4461_ _1211_ _1213_ _1207_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a21o_1
XANTENNA__3506__A2 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3412_ _0093_ _0096_ _0094_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a21oi_1
X_4392_ _1000_ _1136_ _1137_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__nand3_1
X_3343_ _2469_ _2470_ _2426_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__a21o_1
X_3274_ _2399_ _2400_ _2401_ _2404_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__o31a_1
X_5013_ clknet_3_3__leaf_clk _0029_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfxtp_1
XFILLER_26_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout167_A in1_reg\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _2113_ _2114_ net81 _0460_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_21_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4728_ _1502_ _1504_ _1500_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__nand3_2
XANTENNA__3745__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4659_ _1310_ _1416_ _1427_ _1428_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__o211ai_4
XANTENNA__4819__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4273__B net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3961_ _0451_ _0679_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nand2_2
X_2912_ _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_33_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3892_ _0575_ _0571_ _0569_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__o21ai_2
XANTENNA__2632__C1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2843_ _0373_ net75 _1972_ _1974_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__o22ai_2
X_2774_ _1837_ _1838_ _1856_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_41_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4513_ _1124_ _1128_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__nand2_1
X_4444_ _1190_ _1191_ _1057_ _1055_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__a22o_1
X_4375_ _0983_ _1121_ _1120_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__nand3_2
X_3326_ _2342_ _2440_ _2451_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3257_ _2186_ _2185_ _2385_ _2384_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__a2bb2o_2
X_3188_ _2313_ net231 net139 VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__nand3_1
XANTENNA__2606__B net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4915__B2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4549__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input12_A in1[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4715__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_7__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4160_ _0602_ _0607_ _0608_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nand4_1
XANTENNA__3363__A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3111_ _2075_ _2078_ _2080_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__o21ai_1
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4091_ _0784_ _0785_ _0805_ _0806_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a22o_1
X_3042_ net171 net202 VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__nand2_1
XFILLER_63_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4993_ clknet_3_3__leaf_clk _0009_ VGND VGND VPWR VPWR in2_reg\[9\] sky130_fd_sc_hd__dfxtp_4
XFILLER_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3944_ _0652_ _0653_ _0655_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a21o_1
X_3875_ _0266_ net177 net170 VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__and3_1
X_2826_ _1957_ _1958_ _1959_ _1876_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA__4443__A2_N _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2757_ net163 net232 VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__nand2_1
XANTENNA__4373__A2 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2688_ net168 net233 net227 net174 VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__a22oi_1
XFILLER_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4427_ _1174_ _1175_ net137 net179 VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__nand4_1
XANTENNA__4530__C1 _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4358_ _1096_ _1101_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__nand2_1
XANTENNA_input4_A in1[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4289_ _1027_ _1028_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__nor2_1
X_3309_ _2431_ _2435_ _2434_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_1_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2844__C1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout75 net76 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_2
XFILLER_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout86 in1_reg\[15\] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_4
Xfanout97 in1_reg\[13\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_9_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2527__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3358__A net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3660_ net148 net202 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__nand2_1
X_3591_ _0449_ net74 _0160_ _0161_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__o22a_1
X_2611_ _1140_ _1617_ _1574_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21oi_4
X_2542_ _0782_ _0869_ net271 VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__o21ai_1
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3805__B net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4212_ _0938_ _0940_ _0943_ _0785_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__a22oi_4
XFILLER_68_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4143_ _0766_ _0767_ _0867_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand4_4
XPHY_EDGE_ROW_50_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4074_ _0792_ _0794_ net73 _0504_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o2bb2ai_1
X_3025_ net321 VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4652__A net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4976_ net271 net15 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout247_A net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3927_ _0516_ _0643_ _0638_ _0642_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__o211a_1
Xclkload6 clknet_3_7__leaf_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_4
X_3858_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__inv_2
X_3789_ _0499_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__nand2_2
XANTENNA__3418__D net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2809_ _1937_ _1939_ _1920_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__a21o_1
XFILLER_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout232 net233 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_8
Xfanout210 net211 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout221 in2_reg\[8\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_4
Xfanout265 net266 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_4
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4712__D net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4337__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3360__B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4472__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4830_ _1578_ _1580_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4761_ _1536_ _1537_ _1538_ _1398_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__o2bb2ai_1
X_4692_ _1351_ _1464_ _1462_ _1459_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__o211ai_1
X_3712_ _0416_ _0411_ _2481_ _0244_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__o2bb2ai_4
X_3643_ _0293_ _0294_ net279 net283 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__o211a_4
XANTENNA__3536__B1 _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3574_ _0183_ _0189_ _0186_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a21oi_4
X_2525_ net269 net19 VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_1
X_4126_ _0834_ _0846_ _0820_ _0845_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__o211ai_4
XANTENNA_fanout197_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4057_ net245 net239 net91 net86 VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__and4_1
X_3008_ _2140_ _2073_ _2139_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__nand3_2
XFILLER_51_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout152_X net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4959_ _1696_ _1697_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2578__A1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4191__B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3290_ _2418_ _2419_ _2408_ VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__nand3_2
XFILLER_2_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4813_ _1592_ _1593_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__nand2_1
X_4744_ _1430_ _1435_ _1514_ _1287_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__a22oi_2
X_4675_ _1440_ _1441_ _1443_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout112_A in1_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3626_ _0321_ _0317_ _0314_ _0322_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__o211a_1
X_3557_ _0112_ _0254_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__nand2_1
X_2508_ net105 VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__inv_6
XANTENNA__3390__D1 _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3488_ net115 net244 net247 net111 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__nand4_4
XFILLER_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4109_ _0679_ _0828_ net132 net200 _0827_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_39_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2535__A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2790_ net253 net141 VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__nand2_1
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4460_ _1211_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__nand2_1
X_4391_ _0997_ _0998_ _1137_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nand3_2
X_3411_ _0104_ _0111_ _0107_ _2403_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a2bb2o_1
X_3342_ _2466_ _2468_ _2470_ _2426_ VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__o211ai_4
X_3273_ _2395_ _2397_ _2402_ net270 VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__o31a_1
X_5012_ clknet_3_3__leaf_clk _0028_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfxtp_1
XANTENNA__4219__B2 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2650__B1 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2988_ _2113_ _2114_ net253 net129 VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__nand4_1
X_4727_ net212 net206 net89 net84 VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__nand4_2
X_4658_ _1310_ _1416_ _1425_ _1426_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__a2bb2oi_2
X_3609_ _0185_ _0305_ net234 net115 _0304_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__o2111a_4
X_4589_ _1243_ _1346_ _1349_ net179 net132 VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__a32o_1
XFILLER_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3960_ net127 net211 net205 net133 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a22oi_2
X_2911_ _1900_ _1903_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__nand2_1
XFILLER_16_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3891_ _0597_ _0591_ _0586_ _0593_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o2bb2ai_4
X_2842_ _1973_ _1975_ net167 net219 VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__nand4_2
X_2773_ _1839_ _1840_ _1857_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__o21ai_1
X_4512_ _1124_ net179 net142 VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__and3_1
X_4443_ _1190_ _1191_ _1054_ _1058_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__o2bb2a_1
X_4374_ _0980_ _0808_ _0979_ _0949_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a31o_1
XANTENNA__2699__B1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3325_ _2342_ _2440_ _2442_ _2448_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3256_ _2384_ _2385_ _2188_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__nand3_1
XANTENNA__3112__A1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3187_ _2314_ net225 net144 VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__nand3_1
XFILLER_41_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout232_X net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout92_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4715__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3110_ _2236_ _2229_ _2237_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__nand3_2
X_4090_ _0786_ _0805_ _0806_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__nand3_1
X_3041_ _2142_ _2151_ _2141_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__a21boi_2
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4992_ clknet_3_6__leaf_clk _0008_ VGND VGND VPWR VPWR in2_reg\[8\] sky130_fd_sc_hd__dfxtp_1
X_3943_ _0652_ _0653_ _0655_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a21oi_1
X_3874_ _0395_ net70 _0264_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o21a_1
X_2825_ _1871_ _1872_ _1821_ _1768_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__a31o_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2756_ net175 net220 VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__nand2_1
X_2687_ in1_reg\[1\] net174 net233 net227 VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__and4_2
X_4426_ net137 net179 _1174_ _1175_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__a22o_1
X_4357_ _1099_ _1100_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__nand2_1
X_4288_ _0882_ _0892_ _1026_ net273 VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a31o_1
X_3308_ _2436_ _2437_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout182_X net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3239_ _2366_ _2333_ _2367_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__nand3_4
XFILLER_73_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout76 _0482_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_4
Xfanout87 in1_reg\[15\] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_4
Xfanout98 net99 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_6
XFILLER_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4521__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3590_ _0285_ _0277_ _0274_ _0287_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__o211ai_2
X_2610_ _1140_ _1617_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__nand2_1
XANTENNA__3012__B1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2541_ _0782_ _0869_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nor2_1
X_4211_ _0784_ _0809_ _0810_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__nand3_4
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4142_ _0772_ _0865_ _0866_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nand3_2
X_4073_ net229 net223 net110 net102 VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand4_4
X_3024_ _2070_ _2156_ _2155_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__nand3_2
XANTENNA__4933__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4975_ net272 net14 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and2_1
X_3926_ _0516_ _0643_ _0638_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout142_A in1_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3857_ _0382_ _0392_ _0567_ _0574_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a31o_1
X_3788_ _0318_ _0324_ _0496_ _0497_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand4_4
X_2808_ _1940_ _1920_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__nand2_1
X_2739_ _1807_ _1819_ _1873_ _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__o211ai_4
XFILLER_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout200 net203 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
X_4409_ _0882_ _1023_ _1025_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__o21ai_2
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_6
Xfanout211 net212 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_8
Xfanout233 in2_reg\[6\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_6
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__buf_4
Xfanout244 in2_reg\[4\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_4
XFILLER_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3731__B net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout266 in2_reg\[0\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__buf_4
XFILLER_46_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3906__B net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4472__B net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4760_ _1399_ _1536_ _1537_ _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__nand4_2
X_4691_ net77 net69 _1353_ _1350_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__o31a_1
X_3711_ _0242_ _0259_ _0413_ _0414_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__o211ai_4
X_3642_ _0339_ _0297_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nand2_1
X_3573_ _0184_ _0185_ _0183_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2524_ net269 net18 VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__and2_1
X_4125_ _0844_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nor2_1
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4056_ net239 net91 net86 net245 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _2089_ _2091_ _2133_ _2134_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__a22o_1
XFILLER_51_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4958_ _1723_ _1739_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__or2_1
XFILLER_24_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4889_ _1677_ _1678_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__xnor2_1
X_3909_ _0625_ _0628_ _0617_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4007__A2 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4191__B2 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4812_ _1591_ _1592_ _1594_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__nand3_1
X_4743_ _1515_ _1518_ _1519_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__and3_1
X_4674_ _1440_ _1441_ _1443_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__a21oi_1
X_3625_ net82 _0548_ _0197_ _0319_ _0318_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o221ai_4
X_3556_ _0254_ _0256_ _0112_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__a21o_1
X_2507_ net202 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__inv_2
XANTENNA__3390__C1 net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3487_ net240 net109 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nand2_2
XFILLER_29_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4108_ _0827_ _0829_ _0471_ net71 VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__o2bb2ai_2
X_4039_ _0469_ _0473_ _0728_ _0732_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__o31a_1
XANTENNA__2799__A2 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4390_ _1001_ _1133_ _1134_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__nand3_2
X_3410_ net302 _2394_ _2268_ _2392_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a31oi_1
X_3341_ _2426_ _2470_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__nand2_1
X_3272_ _2400_ _2401_ _2396_ _2398_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__o211a_1
X_5011_ clknet_3_3__leaf_clk _0027_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2987_ _2110_ _2116_ _2118_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__nand3b_4
X_4726_ net206 net83 VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__nand2_1
X_4657_ net201 net101 _1421_ _1424_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__a22o_1
X_3608_ net234 net115 _0304_ _0306_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a22o_1
X_4588_ net131 net179 VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_10_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3539_ _0115_ _0234_ _0235_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nand3_2
XFILLER_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2641__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkload0_A clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2910_ net172 net214 VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3890_ net267 _0609_ _0610_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__and3_1
X_2841_ net160 net155 net233 net226 VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__nand4_1
X_2772_ _1902_ _1905_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__nand2_1
XANTENNA__3808__C net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4511_ _1168_ _1264_ _1265_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nand3_2
X_4442_ _1048_ _1046_ _1193_ _1058_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a211oi_1
X_4373_ _0970_ net184 net143 _0967_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a31o_1
X_3324_ _2445_ _2447_ _2442_ VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__a21o_1
X_3255_ _2385_ _2188_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__nand2_1
XFILLER_26_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3186_ net144 net139 net231 net225 VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout172_A in1_reg\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4709_ _1408_ _1405_ _1407_ _1441_ _1446_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__o2111a_1
XANTENNA_fanout85_A in1_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2862__A1 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3660__A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3040_ _2141_ _2171_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_46_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4991_ clknet_3_6__leaf_clk _0007_ VGND VGND VPWR VPWR in2_reg\[7\] sky130_fd_sc_hd__dfxtp_1
X_3942_ _0651_ _0647_ _0653_ _0655_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__o211ai_2
XANTENNA__3389__A2_N net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3873_ _0590_ _0587_ _0585_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand3_2
X_2824_ _1821_ _1871_ _1872_ _1768_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__a31oi_1
X_2755_ _1833_ _1834_ _1836_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__o21ai_1
X_2686_ net168 net226 VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__nand2_1
X_4425_ _1174_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__nand2_1
X_4356_ _1096_ _1098_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a21oi_1
X_3307_ _2432_ _2433_ net236 net129 VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__nand4_1
X_4287_ _0882_ _0892_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a21oi_1
X_3238_ _2334_ _2364_ _2365_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__nand3_2
X_3169_ net171 net198 _2297_ _2298_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout77 _0471_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_6
Xfanout88 net89 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_4
Xfanout99 in1_reg\[13\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_6
XFILLER_10_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5022__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3012__B2 net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2540_ net173 _0858_ _0847_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a21o_1
XFILLER_5_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4210_ _0785_ _0805_ _0806_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__nand3_1
XFILLER_68_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4141_ _0863_ _0864_ _0770_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__a21oi_1
X_4072_ net222 net102 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nand2_2
XFILLER_55_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3023_ _2141_ _2142_ _2151_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__a21o_1
X_4974_ net271 net13 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and2_1
X_3925_ _0639_ _0640_ _0643_ _0516_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__o2bb2ai_2
X_3856_ net165 net177 VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand2_1
X_3787_ _0317_ _0315_ _0320_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__o211ai_4
X_2807_ _1918_ _1919_ _1937_ _1939_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__o211ai_1
X_2738_ _1828_ _1829_ _1859_ _1862_ _1869_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__o221ai_4
X_4408_ _1155_ _0886_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__nor2_1
XFILLER_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2669_ _1542_ _1771_ _1800_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__nand3_2
Xfanout201 net203 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_2
Xfanout223 net227 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_6
Xfanout212 in2_reg\[9\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_12
X_4339_ _0951_ _1079_ net119 net200 _1078_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__o2111ai_2
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_12
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_4
Xfanout256 in2_reg\[2\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
Xfanout267 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_2
XANTENNA__3731__C net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3459__B net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4472__C net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3710_ _0242_ _0259_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__o21ai_1
X_4690_ _1352_ net179 net131 VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__and3_1
X_3641_ _0293_ _0294_ _0339_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__o21ai_2
X_3572_ _0222_ _0178_ _0221_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a21boi_2
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2523_ net269 net32 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__and2_1
X_4124_ _0820_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand2_1
Xinput1 in1[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_4055_ net239 net91 net86 net245 VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a22oi_2
X_3006_ _2089_ _2091_ _2133_ _2134_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__nand4_1
X_4957_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__inv_2
XFILLER_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4888_ _0515_ net68 _1623_ _1625_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__o31a_1
X_3908_ _0485_ _0622_ net234 net103 _0621_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__o2111ai_1
X_3839_ net279 _0340_ _0550_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__nand3_4
XFILLER_3_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4007__A3 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4914__D net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4811_ _1591_ _1592_ _1594_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_38_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2715__C in1_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4742_ _1515_ _1518_ _1519_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__a21oi_1
X_4673_ _1317_ _1442_ _1441_ _1440_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o211ai_4
X_3624_ _0315_ _0320_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_47_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3555_ _0113_ _0251_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__o21ai_1
X_3486_ _0184_ _0185_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__nand2_2
X_2506_ net111 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__inv_4
XFILLER_29_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4107_ _0827_ _0829_ _0823_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
X_4038_ _0469_ _0728_ _0473_ net159 net177 VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__o311a_1
XPHY_EDGE_ROW_56_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout70_X net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in2[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3340_ _2461_ _2463_ _2427_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__nand3_4
X_5010_ clknet_3_6__leaf_clk _0026_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfxtp_1
X_3271_ _2069_ _2275_ _2168_ _2400_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_36_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2986_ _2110_ _2115_ _2117_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__nor3_4
X_4725_ _1423_ _1501_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout215_A in2_reg\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4656_ _1306_ _1423_ net201 net101 _1421_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__o2111ai_4
X_4587_ _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__inv_2
X_3607_ net234 net115 _0304_ _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a22oi_4
X_3538_ _0226_ _0232_ _0156_ _0231_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__o211ai_1
X_3469_ _0158_ _0165_ _0166_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__nand3_4
XFILLER_67_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2641__A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3483__A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2840_ net161 net155 net232 net226 VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__and4_1
X_2771_ _1901_ _1904_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__nor2_1
XANTENNA__3808__D net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4510_ _1268_ _1167_ _1267_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__nand3_2
X_4441_ _1190_ _1191_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4372_ net142 net179 VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__nand2_1
XANTENNA__2699__A2 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3323_ net82 _0515_ _2338_ _2446_ _2445_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__o221ai_4
X_3254_ _2253_ _2282_ _2379_ _2380_ VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_49_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3185_ net139 net225 VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout165_A net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2969_ _2098_ _2100_ net145 net236 VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__and4_1
X_4708_ _1407_ _1413_ _1441_ _1446_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__a22oi_4
X_4639_ net106 net193 net187 net112 VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__a22oi_4
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4549__D net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout78_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3363__D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4827__B1 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4990_ clknet_3_6__leaf_clk _0006_ VGND VGND VPWR VPWR in2_reg\[6\] sky130_fd_sc_hd__dfxtp_2
X_3941_ _0652_ _0653_ _0655_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__and3_1
XFILLER_31_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3872_ _0403_ _0408_ _0585_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand3_1
X_2823_ _1956_ _1828_ _1955_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__nand3_4
X_2754_ _1830_ _1864_ _1865_ _1868_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__o2bb2ai_1
X_2685_ _1805_ _1820_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__nand2_1
X_4424_ _1098_ _1104_ _1170_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__nand3_2
X_4355_ _0962_ _0978_ _0964_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__o21ai_2
X_3306_ net236 net129 _2432_ _2433_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__a22o_1
X_4286_ _1024_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nand2_1
XFILLER_58_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3237_ _2366_ _2367_ _2333_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__a21oi_2
X_3168_ _2297_ _2298_ net171 net197 VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_1_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout168_X net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3099_ net149 net225 VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__nand2_1
XFILLER_13_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout89 net90 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_52_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout78 net79 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_6
XFILLER_6_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input10_A in1[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2840__A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4140_ _0770_ _0863_ _0864_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nand3_4
X_4071_ _0643_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_2
X_3022_ _2141_ _2142_ _2149_ _2150_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__nand4_1
X_4973_ net270 net12 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and2_1
XFILLER_51_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3924_ net229 net223 net114 net110 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__and4_1
X_3855_ _0373_ net70 VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nor2_1
X_3786_ _0496_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout128_A in1_reg\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2806_ _1918_ _1919_ _1931_ _1938_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__o22a_1
X_2737_ _1870_ _1830_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__nand2_1
XANTENNA__2762__A1 _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2668_ _1800_ _1802_ _1773_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a21o_1
X_4407_ _1156_ _0607_ _0608_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_6_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout202 net203 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_4
Xfanout213 net215 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_4
X_2599_ net255 net157 _1477_ _1487_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__a22o_1
X_4338_ _1078_ _1080_ _1073_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a21o_1
Xfanout235 in2_reg\[5\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_8
Xfanout246 net247 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_6
Xfanout224 net227 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_8
Xfanout268 _0592_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_2
X_4269_ _0772_ _0865_ _0866_ _0867_ _0768_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a32o_1
XANTENNA_input2_A in1[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout257 net258 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_57_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4472__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3640_ _0338_ _0297_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_11_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3571_ _0266_ _0269_ _0268_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__a21o_1
X_2522_ net270 net31 VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__and2_1
XANTENNA_clkbuf_3_0__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4123_ _0835_ _0837_ _0841_ _0842_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand4_2
X_4054_ net235 net97 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nand2_1
Xinput2 in1[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3005_ _2136_ _2092_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__nand2_1
XANTENNA__3472__A2 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4956_ _1720_ _1738_ _1737_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21oi_1
X_4887_ _1675_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__nand2_1
X_3907_ _0485_ _0622_ net234 net103 _0621_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__o2111a_1
XANTENNA__3576__A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3838_ _0481_ _0553_ _0552_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nand3_4
XFILLER_3_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ _0469_ _0474_ _0477_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__o21ai_2
XFILLER_42_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2565__A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4810_ _1485_ net176 net118 _1483_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__a31oi_1
XFILLER_61_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4741_ _1409_ _1412_ _1431_ _1430_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__o31a_2
X_4672_ _1317_ _1442_ _1441_ _1440_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__o211a_1
X_3623_ _0318_ _0320_ _0315_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a21o_1
X_3554_ _0251_ _0113_ _0102_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a21oi_1
X_2505_ net112 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkinv_4
X_3485_ net244 net115 net111 net247 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout195_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4106_ _0823_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__nand2_1
X_4037_ _0737_ _0740_ _0612_ _0742_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout248_X net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4939_ net66 _1730_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__and3_1
XANTENNA__3905__B1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3270_ _2069_ _2275_ _2168_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__and3_1
XFILLER_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4724_ net212 net84 VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nand2_1
X_2985_ net81 _0460_ _2113_ _2114_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__o211ai_2
X_4655_ _1421_ _1424_ _1418_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout110_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4586_ _1346_ _1348_ _1244_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nand3b_2
X_3606_ net245 net240 net108 net103 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nand4_4
XANTENNA_fanout208_A net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4560__B1 _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3537_ _0151_ _0153_ _0233_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o21a_1
X_3468_ _0168_ _0157_ _0167_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__nand3_4
X_3399_ _2384_ _2386_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__nand2_1
XFILLER_69_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2933__A net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2652__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2929__A1 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2770_ _1899_ _1900_ _1823_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_41_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4440_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__inv_2
X_4371_ _1116_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__nand2_1
X_3322_ _2442_ _2447_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__nand2_1
X_3253_ _2283_ _2383_ _2382_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__nand3_2
X_3184_ _2313_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_49_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout158_A in1_reg\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2968_ _2098_ _2100_ net80 net78 VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__o2bb2a_1
X_4707_ _1403_ _1453_ _1454_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__a21boi_1
X_4638_ net112 net107 net193 net187 VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__nand4_4
X_2899_ _1936_ _1941_ _2030_ _2031_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__o211ai_1
X_4569_ _1328_ _1329_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__nand2_1
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2647__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4827__B2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2838__B1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4772__B net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3940_ _0513_ _0517_ _0519_ _0652_ _0653_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__o2111ai_1
X_3871_ _0402_ _0407_ _0588_ _0589_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__o211ai_4
X_2822_ _1955_ _1956_ _1825_ _1827_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__o2bb2ai_2
X_2753_ _1832_ _1866_ _1867_ _1830_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__a31oi_1
X_2684_ _1801_ _1806_ _1770_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__o21bai_1
X_4423_ _1096_ _1171_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__nand3_2
X_4354_ _0962_ _0978_ _0964_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__o21a_1
X_3305_ _2354_ _2430_ _2429_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__o21ai_1
XFILLER_58_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4285_ _1017_ _1022_ _1015_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nand3_2
X_3236_ _2344_ _2350_ _2363_ _2349_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__o211ai_4
X_3167_ _2175_ _2179_ _2293_ _2294_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__o211ai_4
X_3098_ net154 net219 VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3579__A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout79 _0438_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_4
Xfanout68 net70 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout230_X net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout90_A in1_reg\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3190__C1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4070_ net228 net102 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nand2_2
X_3021_ _2141_ _2142_ _2152_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__nand3_1
X_4972_ net270 net11 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__and2_1
X_3923_ net222 net110 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nand2_4
X_3854_ _0569_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2805_ _1931_ _1938_ _1937_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__o21ai_1
X_3785_ net261 net313 net92 net87 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__nand4_4
X_2736_ _1859_ _1862_ _1865_ _1868_ _1830_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__o221ai_4
X_2667_ _1778_ _1780_ _1796_ _1799_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__a22o_1
X_4406_ _0604_ _0752_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__nor3_4
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3581__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout203 in2_reg\[11\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_4
X_2598_ _1477_ _1487_ net254 net157 VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__nand4_1
X_4337_ _0493_ net71 _0951_ _1079_ _1078_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__o221ai_4
Xfanout247 net251 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_8
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_6
Xfanout236 net238 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
Xfanout269 net270 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_2
X_4268_ _0768_ _0868_ _0867_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__o21ai_1
Xfanout258 in2_reg\[1\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_6
X_3219_ _2336_ _2346_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_57_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4199_ _0643_ _0791_ _0794_ _0790_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__a22o_1
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3772__A in2_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout93_X net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3570_ _0266_ _0269_ _0268_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a21oi_4
X_2521_ net270 net30 VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and2_1
XFILLER_5_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4122_ _0835_ _0837_ _0841_ _0842_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__and4_1
X_4053_ _0634_ _0665_ _0633_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__o21ai_1
Xinput3 in1[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_3004_ _2088_ _2090_ _2133_ _2134_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__o211ai_2
X_4955_ _1747_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3906_ _0623_ net105 net234 VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_62_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout238_A in2_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4886_ _1630_ _1673_ _1674_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout140_A net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3837_ _0547_ _0550_ _0480_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a21oi_2
X_3768_ _0470_ _0473_ _0476_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a21oi_2
X_2719_ _1848_ _1851_ _1844_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__a21o_1
X_3699_ _0236_ _0230_ _0400_ _0401_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2565__B net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4740_ _1512_ _1513_ _1034_ _1285_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4671_ _1301_ _1319_ _1317_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a21o_1
X_3622_ _0318_ _0320_ net82 _0548_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o2bb2ai_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ _0098_ _0100_ _0101_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a32o_1
X_3484_ net246 net108 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nand2_2
X_2504_ net121 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__inv_6
X_4105_ net127 net119 net322 net205 VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand4_2
XANTENNA_fanout188_A net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4036_ _0571_ _0577_ _0737_ _0740_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_39_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4690__B net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4938_ net180 net83 net177 net89 VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_22_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4869_ net95 net182 _1653_ _1655_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a22o_1
XANTENNA__3905__B2 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4105__B net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2984_ net81 _0460_ _2113_ _2114_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__o211a_4
X_4723_ net201 net94 VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__and2_1
X_4654_ net71 _0537_ _1306_ _1423_ _1421_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__o221ai_4
X_4585_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__inv_2
X_3605_ net240 net103 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout103_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3536_ _0156_ _0231_ _0232_ _0226_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__o2bb2ai_2
X_3467_ _0163_ _0164_ _0159_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a21o_1
X_3398_ _0093_ _0095_ _0096_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nand3_1
X_4019_ _0723_ _0724_ _0734_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nand3_4
XFILLER_25_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2492__Y _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2612__A1_N _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2562__B1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5025__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4370_ _0946_ _1107_ _1111_ _1113_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__nand4_4
XFILLER_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3321_ net82 _0515_ _2448_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__o21ai_2
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3252_ _2376_ _2377_ _2309_ VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__a21o_1
X_3183_ net139 net231 VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_49_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3287__D net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2967_ net248 net241 net139 net136 VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__nand4_4
X_4706_ _1454_ _1480_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__nand2_1
X_2898_ _1936_ _1941_ _2030_ _2031_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__o211a_2
XANTENNA_fanout220_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4637_ net112 net107 net193 net187 VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__and4_1
X_4568_ _1221_ _1236_ _1323_ _1327_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nand4_2
X_4499_ _1197_ _1255_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__nand2_1
XFILLER_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3519_ _0215_ _0216_ _0180_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_4_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4288__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2838__B2 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2838__A1 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3870_ _0270_ _0403_ _0404_ _0399_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__o2bb2ai_2
X_2821_ _1863_ _1888_ _1951_ _1952_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__o211ai_2
X_2752_ _1815_ _1883_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__nand2_1
XFILLER_31_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4422_ _1098_ _1100_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__nand2_1
X_2683_ _1804_ _1772_ _1803_ _1769_ _1767_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a32oi_4
X_4353_ _1096_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__nand2_1
X_4284_ _0876_ _1020_ _1019_ _1018_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__o211ai_2
X_3304_ _2432_ _2433_ _2429_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__a21o_1
X_3235_ _2349_ _2351_ _2357_ _2358_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__o2bb2ai_2
X_3166_ _2296_ _2290_ _2287_ _2295_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__o211ai_4
X_3097_ _2096_ _2100_ _2098_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a21boi_2
XANTENNA_fanout268_A _0592_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout69 net70 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_2
X_3999_ _0673_ net291 _0710_ _0711_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__nand4_4
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout83_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2840__C net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3655__D net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3020_ _2143_ _2151_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__nand2_1
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4971_ net270 net10 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__and2_1
XANTENNA__4433__B1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3922_ _0639_ _0640_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand2_2
X_3853_ _0567_ _0568_ _0383_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_14_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2804_ _1932_ _1933_ _1922_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__nand3_1
X_3784_ _0319_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nand2_1
X_2735_ _1828_ _1829_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__o21ai_1
X_2666_ _1794_ _1797_ _1796_ _1778_ _1780_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__o2111ai_4
X_4405_ _0883_ _0882_ _1024_ _1025_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_6_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4336_ net210 net113 net205 net111 VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__nand4_1
Xfanout204 net205 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_6
X_2597_ net266 net260 net151 net286 VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__nand4_4
Xfanout215 in2_reg\[9\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_2
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_12
XFILLER_59_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_2
X_4267_ _0899_ _0900_ _0995_ _0997_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__nand4_1
XANTENNA__4974__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout259 net261 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_6
XFILLER_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout248 net251 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_4
X_4198_ _0923_ _0927_ _0926_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__o21ai_1
X_3218_ _2348_ _2335_ _2347_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_57_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3149_ _2263_ _2148_ _2261_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_65_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3466__A1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3666__C net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2520_ net270 net29 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__and2_1
XFILLER_5_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4121_ _0821_ _0832_ _0833_ _0843_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a31o_1
X_4052_ _0544_ _0671_ _0769_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__o21ai_1
XFILLER_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput4 in1[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_3003_ _2133_ _2134_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__nand2_1
XFILLER_36_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4954_ _1746_ _1744_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__and2_1
X_3905_ _0621_ _0623_ net79 _0537_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA__2968__B1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4885_ _1620_ _1626_ _1627_ _1673_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__a32o_1
XFILLER_32_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3836_ net288 _0534_ _0535_ _0511_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand4_4
XANTENNA__4969__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3767_ _0470_ _0472_ _0430_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__a21o_1
X_2718_ _1789_ _1846_ _1844_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__o21ai_1
X_3698_ _0230_ _0236_ _0400_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o211a_1
XFILLER_10_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2649_ net263 net141 VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__nand2_2
XANTENNA__2639__D net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4319_ _0940_ _1059_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand3b_4
XFILLER_59_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2495__Y _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4670_ _1312_ _1313_ _1302_ _1300_ _1299_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__a311oi_4
X_3621_ _0320_ net98 net313 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nand3_2
X_3552_ _0094_ _0099_ _0249_ _0250_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o211ai_2
X_2503_ net221 VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__inv_2
X_3483_ net244 net115 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nand2_1
X_4104_ net119 net205 VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__nand2_1
X_4035_ _0754_ _0610_ net273 _0753_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_39_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout250_A net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4937_ _1728_ _1729_ net180 net83 VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_22_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4868_ net95 net182 _1653_ _1655_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__a22oi_1
X_3819_ _0525_ _0528_ _0530_ _0279_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__o2bb2ai_1
X_4799_ _1566_ _1579_ _1581_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__nand3_1
XANTENNA__3366__B1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3669__A1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap66 _1710_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
XANTENNA__2682__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4105__C net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2983_ _2113_ _2114_ _2111_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__a21o_1
X_4722_ _1418_ _1420_ _1424_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__o21ai_2
X_4653_ net212 net206 net94 net89 VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nand4_2
X_4584_ _1226_ _1231_ _1243_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__o211ai_4
X_3604_ _0302_ _0188_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand2_4
X_3535_ _0151_ _0153_ _0226_ _0232_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o22a_1
X_3466_ _0449_ net74 _0163_ _0164_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o211ai_2
X_3397_ _0093_ _0095_ _0096_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and3_1
XANTENNA__4982__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4018_ _0723_ _0724_ _0734_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a21o_1
XFILLER_16_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input26_A in2[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3814__A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4116__B net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3320_ _2338_ _2446_ net252 net108 _2445_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__o2111ai_4
XANTENNA__4786__B net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3251_ _2305_ _2307_ _2376_ _2377_ VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__o211ai_1
X_3182_ net144 net225 VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__nand2_1
XFILLER_66_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2966_ net248 net241 net139 net136 VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__and4_1
X_4705_ _1449_ _1452_ _1403_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__o21ai_1
X_2897_ _2027_ _2004_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__nand2_1
X_4636_ net118 net181 VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout213_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4977__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4567_ _1323_ _1327_ _1329_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__nand3_1
XANTENNA__3741__B1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4498_ _1243_ _1244_ _1201_ _1193_ _1059_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a32oi_1
X_3518_ _0214_ _0192_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_2
X_3449_ _2485_ _0070_ _0071_ _0073_ _2483_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a32o_1
XFILLER_72_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2944__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4217__A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2838__A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2820_ _1889_ _1954_ _1953_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__nand3_2
X_2751_ _1814_ _1880_ _1816_ _1765_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and4_1
X_2682_ net271 _1818_ _1817_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__and3_1
XFILLER_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4421_ _1065_ net183 net137 _1066_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__a31o_1
X_4352_ _1090_ _1091_ _1094_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand3_4
X_4283_ _0876_ _1020_ _1019_ _1018_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__o211a_1
X_3303_ net247 net241 net123 net117 VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__nand4_4
X_3234_ _2349_ _2351_ _2360_ _2361_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__o2bb2ai_1
X_3165_ net160 net154 net213 net207 _2288_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__a41o_1
XFILLER_54_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3096_ _2098_ net237 net145 _2099_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__a31oi_2
XANTENNA_fanout163_A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3579__C net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3998_ _0672_ _0674_ _0716_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__o21ai_2
X_2949_ _2079_ _2080_ _2075_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout216_X net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4619_ _1383_ _1386_ _1382_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__o21bai_4
XANTENNA__2498__Y _0427_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4592__D net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2840__D net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4970_ net269 net9 VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
XANTENNA__4433__B2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4433__A1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3921_ net227 net117 net110 net230 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a22oi_2
X_3852_ _0382_ _0392_ _0567_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_14_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2803_ _1850_ _1921_ _1933_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__o21ai_4
X_3783_ net313 net92 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__nand2_1
XANTENNA__5038__CLK clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2734_ _1859_ _1862_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2665_ _1796_ _1799_ _1781_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__a21o_1
XANTENNA__2759__B net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4404_ _0882_ _0883_ _1024_ _1025_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__and4_1
X_2596_ _1444_ _1455_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_6_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4335_ net204 net107 VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__nand2_2
Xfanout205 net206 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_6
Xfanout227 in2_reg\[7\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_8
Xfanout216 net221 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_4
XFILLER_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout238 in2_reg\[5\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_6
X_4266_ _0899_ _0900_ _0995_ _0997_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a22o_1
Xfanout249 net251 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_2
XFILLER_67_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4197_ _0915_ _0925_ _0924_ _0912_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__o211ai_2
X_3217_ _2340_ _2343_ _2337_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_57_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3148_ net273 _2278_ _2279_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__nor3_1
X_3079_ net236 net141 VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__nand2_1
XFILLER_54_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3163__A1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout79_X net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3466__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3666__D net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4120_ _0835_ _0837_ _0843_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__a21bo_1
X_4051_ _0715_ net289 _0675_ _0672_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a31oi_4
XANTENNA__4654__A1 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in1[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_3002_ _2134_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__inv_2
X_4953_ _1744_ _1746_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__nor2_1
X_3904_ net234 net103 _0621_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a22oi_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2968__B2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4884_ _1668_ _1669_ _1663_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__nand3_1
X_3835_ _0545_ _0536_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout126_A in1_reg\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3766_ _0372_ _0379_ _0470_ _0472_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a2bb2oi_1
XANTENNA__4590__B1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2717_ _1848_ _1851_ _1845_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a21o_1
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3697_ _0347_ net277 _0391_ _0393_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__o2bb2ai_4
X_2648_ net257 net147 VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__nand2_1
X_2579_ _1271_ _1282_ _1205_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a21oi_1
X_4318_ net79 _0570_ _1044_ _1051_ _1052_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__o221ai_4
XFILLER_59_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4249_ _0983_ _0984_ _0949_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a21o_1
XFILLER_59_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4645__A1 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4870__D net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3958__B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3974__A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3620_ net265 net261 net93 net87 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__nand4_4
X_3551_ _0249_ _0250_ _0094_ _0099_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__a211o_1
X_2502_ net131 VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__inv_2
X_3482_ in2_reg\[5\] net123 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nand2_1
X_4103_ _0682_ _0824_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__nand2_2
X_4034_ _0426_ _0598_ _0599_ _0750_ _0751_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a32oi_1
XFILLER_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout243_A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4936_ net186 net88 net176 VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_22_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4867_ net194 net191 net90 net84 VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__nand4_2
X_3818_ _0279_ _0530_ _0528_ _0525_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__o211ai_2
X_4798_ _1570_ _1571_ _1577_ _1578_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__nand4_1
XANTENNA__3366__B2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3749_ _0455_ _0448_ _0444_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__o211a_2
XANTENNA__3669__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap67 _2119_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
XFILLER_70_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4105__D net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4857__A1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2982_ _2113_ _2114_ _2111_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__a21oi_4
X_4721_ _1494_ _1496_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__nand2_1
X_4652_ net206 net88 VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nand2_4
Xinput30 in2[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XANTENNA__4545__B1 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3603_ net240 net108 net103 net245 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a22oi_1
X_4583_ _1202_ _1244_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__nand2_1
X_3534_ _0233_ _0156_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__nand2_1
X_3465_ _0163_ _0164_ net140 net219 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__nand4_2
X_3396_ _0093_ _0095_ _0096_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout193_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4017_ _0723_ _0724_ _0734_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21oi_4
XFILLER_16_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3036__B1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4919_ _1709_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nor2_1
XFILLER_4_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input19_A in2[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3814__A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4116__C net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3971__B net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3250_ _2305_ _2307_ _2377_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__o21ai_1
X_3181_ _2211_ _2216_ _2212_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__a21oi_2
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_53_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4704_ _1459_ _1478_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__nand2_1
X_2965_ _1997_ _2097_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nand2_2
XANTENNA__4323__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2896_ _2005_ _2021_ _2025_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__nand3_1
X_4635_ _1034_ net85 net216 VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__and3_1
X_4566_ _1323_ _1327_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout206_A in2_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3517_ _0190_ _0191_ _0211_ _0213_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__o211ai_2
XANTENNA__2778__A net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4497_ _1239_ _1242_ _1201_ _1244_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o211ai_1
X_3448_ _2483_ _0074_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_71_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3379_ _2483_ _0073_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__nand2_1
XFILLER_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2573__D net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2750_ _1817_ _1884_ _1885_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__o21a_1
X_2681_ _1814_ _1816_ _1764_ _1765_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__a211o_1
X_4420_ _1065_ net183 net137 _1066_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a31oi_1
X_4351_ _1092_ _1093_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand3_4
X_4282_ _0876_ _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__nor2_1
X_3302_ _2354_ _2430_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__nand2_1
X_3233_ _2353_ _2359_ _2362_ _2351_ _2349_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__o2111ai_1
XANTENNA_clkbuf_3_3__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3164_ net167 net202 _2291_ _2292_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__a22o_1
X_3095_ _2221_ _2223_ _2224_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand3_2
XFILLER_54_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout156_A in1_reg\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3997_ net287 net291 _0710_ _0711_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a22oi_4
X_2948_ _2079_ _2080_ _2075_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__a21oi_1
X_4618_ _1379_ _1381_ _1383_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout111_X net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2879_ net257 net121 VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout209_X net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4549_ net212 net204 net101 net96 VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout69_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2865__B net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4433__A2 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3920_ net229 net110 VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand2_2
XFILLER_63_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3851_ _0382_ _0392_ _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_14_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3782_ _0491_ _0492_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nor2_2
X_2802_ _1923_ _1934_ _1935_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__nand3_4
X_2733_ _1832_ _1866_ _1867_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__nand3_2
X_2664_ _1796_ _1799_ _1781_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__a21oi_2
X_4403_ _1150_ _1152_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__and2_1
X_2595_ net260 net152 net286 net262 VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__a22oi_4
XANTENNA__2759__C net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4334_ _1074_ _1076_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_6_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout206 in2_reg\[10\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_6
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_4
Xfanout228 net229 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_6
X_4265_ _0995_ _0997_ _0901_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__a21o_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_6
X_4196_ _0776_ _0909_ _0915_ _0925_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__o2bb2ai_2
X_3216_ net82 _0504_ _2194_ _2341_ _2340_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__o221ai_4
X_3147_ _2170_ _2277_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout273_A net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3078_ _2199_ _2208_ _2207_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout159_X net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3163__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2966__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3387__C1 net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4050_ net290 _0713_ _0715_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand3_2
XANTENNA__4654__A2 _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 in1[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_3001_ _2131_ _2095_ _2130_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_19_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3862__B1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4952_ _1727_ _1733_ _1732_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__a21oi_1
X_4883_ _1663_ _1670_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__nand3b_1
X_3903_ net246 net239 net98 net92 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_62_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3834_ _0546_ _0549_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nor2_1
X_3765_ _0374_ _0380_ _0470_ _0472_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__nand4_1
X_3696_ _0347_ net278 _0390_ _0394_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nand4_4
X_2716_ net81 net80 _1786_ _1849_ _1848_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__o221ai_4
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout119_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2647_ net254 net151 VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__nand2_2
X_2578_ _0362_ net81 _1227_ _1238_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__o211ai_2
X_4317_ _1057_ _1055_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__nand2_4
XFILLER_19_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4248_ _0980_ _0808_ _0979_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__nand3_4
XANTENNA__4645__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4179_ _0905_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__nor2_1
XFILLER_55_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3081__A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_51_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5028__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3974__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3550_ _0249_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nand2_1
X_2501_ net126 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkinv_4
X_3481_ net236 net123 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4102_ net119 net211 net205 net128 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a22oi_4
X_4033_ _0603_ _0610_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4935_ net68 net88 net186 VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_22_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4866_ net194 net186 net90 net84 VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout236_A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4797_ _1570_ _1571_ _1577_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__nand3_1
X_3817_ _0525_ _0528_ _0529_ _0277_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_21_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3748_ _0450_ _0452_ _0445_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__a21o_1
X_3679_ _0374_ _0376_ _0357_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__a21o_1
XANTENNA__2947__C net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2981_ net121 net257 net262 net115 VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__nand4_4
X_4720_ net112 net181 _1491_ _1492_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a22o_1
X_4651_ _1309_ _1419_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__nand2_2
Xinput31 in2[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_3602_ net245 net103 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__nand2_2
Xinput20 in2[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
X_4582_ _1239_ _1242_ _1201_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__o21ai_1
XANTENNA__4545__B2 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3533_ _0151_ _0153_ _0226_ _0232_ _0231_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o221ai_4
X_3464_ _0163_ _0164_ _0449_ net74 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_69_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3225__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3395_ _0093_ _0095_ _0096_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout186_A net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4016_ _0725_ _0734_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4918_ _1700_ _1701_ _1706_ _1707_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__nor4_1
XANTENNA__3587__A2 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout141_X net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4849_ _1634_ _1604_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__nand2_1
XFILLER_32_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout99_A in1_reg\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4775__A1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4786__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3045__A net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3180_ _2225_ _2248_ _2227_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__a21boi_2
XANTENNA__5033__Q in1_reg\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2964_ net248 net136 VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__nand2_2
X_4703_ _1462_ _1465_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__nand2_1
X_2895_ _2001_ _2003_ _2021_ _2025_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__nand4_2
X_4634_ _1400_ _1401_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__nand2_1
X_4565_ _1221_ _1236_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout101_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3516_ _0190_ _0191_ _0213_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__o21ai_1
X_4496_ _1243_ _1244_ _1201_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2778__B net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3447_ _0117_ _0143_ _0144_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__nand3_4
X_3378_ _2484_ _0072_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__nor2_1
XFILLER_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone23 _1156_ _0607_ _0608_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__nand3_2
XANTENNA__4233__B net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone34 in2_reg\[10\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input31_A in2[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2680_ _1765_ _1814_ _1816_ _1815_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__a31oi_1
X_4350_ _0928_ _0931_ _0926_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a21boi_2
X_3301_ net241 net123 net117 net247 VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__a22oi_4
XANTENNA__3568__A2_N net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4281_ _0872_ _0759_ _0871_ _0758_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a31oi_2
X_3232_ _2353_ _2359_ _2362_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__o21ai_4
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3163_ _0373_ net72 _2291_ _2292_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__o211ai_2
X_3094_ _2223_ _2224_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_17_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3996_ _0710_ _0711_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__nand2_1
X_2947_ net155 net150 net232 net226 VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__nand4_2
X_4617_ _1161_ _1157_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a21oi_4
X_2878_ _1928_ _2010_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_9_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4548_ net212 net206 net100 net96 VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__and4_2
X_4479_ _1222_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4902__A1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4419__A _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3850_ _0382_ _0386_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__nand2_1
X_3781_ _0302_ _0488_ _0483_ _0487_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__o211a_4
X_2801_ _1923_ _1934_ _1935_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__and3_1
X_2732_ _1832_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2663_ _1777_ _1779_ _1794_ _1797_ _1796_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__o221ai_4
X_4402_ _1144_ _1146_ _1149_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__o21ai_2
X_2594_ net262 net286 VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__nand2_1
XANTENNA__2759__D net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4333_ net113 net204 net107 net210 VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_6_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4264_ _0901_ _0995_ _0997_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nand3_1
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_6
Xfanout218 net221 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
Xfanout207 net209 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_4
X_3215_ _2194_ _2341_ net254 net116 _2340_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__o2111ai_4
XFILLER_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4195_ _0921_ _0910_ _0920_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nand3_2
X_3146_ _2277_ _2170_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__and2b_1
X_3077_ _2200_ _2201_ _2206_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__nand3_1
XFILLER_50_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout221_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3979_ _0697_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nor2_1
XFILLER_50_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3387__B1 _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3963__D net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4639__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput7 in1[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_3000_ _2026_ _2094_ _2128_ _2129_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_19_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3862__B2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4951_ net88 net180 net83 net176 _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__a41o_1
X_4882_ _0537_ net68 _1666_ _1667_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__o211ai_1
X_3902_ net239 net92 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_62_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3833_ _0511_ net288 _0536_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nand3_4
X_3764_ _0433_ _0463_ _0464_ _0431_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a31o_1
X_3695_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__inv_2
X_2715_ net262 net257 in1_reg\[6\] net135 VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__nand4_1
X_2646_ _1477_ _1531_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__nand2_1
X_2577_ _1227_ _1238_ _1260_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a21o_1
X_4316_ _1040_ _1045_ _1049_ _0904_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a31o_1
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4247_ _0800_ _0807_ _0981_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__o211ai_4
X_4178_ net235 net91 net86 net239 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a22oi_2
XANTENNA__3898__A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout269_X net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3129_ _2259_ _2260_ _2173_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__a21oi_2
XFILLER_70_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4225__C net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4432__A net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3974__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2500_ net137 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__inv_4
X_3480_ _2455_ _2450_ _2439_ _2459_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__a22oi_4
XFILLER_51_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5036__Q in1_reg\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4101_ net124 net210 VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
X_4032_ _0750_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand2_2
X_4934_ _1659_ _1661_ _1702_ _1706_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_22_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4865_ net191 net90 net83 net194 VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__a22o_1
XANTENNA_fanout131_A net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4796_ _1570_ _1571_ _1577_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__a22o_1
XANTENNA_fanout229_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3816_ net134 _0278_ net221 _0279_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a31o_1
X_3747_ _0366_ _0447_ _0445_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o21ai_1
X_3678_ _0357_ _0376_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__nand2_2
X_2629_ _1764_ _1765_ _1766_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__nor3_1
XANTENNA__2947__D net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2980_ _2013_ _2112_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__nand2_4
XFILLER_14_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4650_ net206 net95 net89 net212 VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__a22oi_1
Xinput10 in1[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_3601_ net234 net115 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nand2_1
Xinput21 in2[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput32 in2[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
X_4581_ _1225_ net183 net131 _1226_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a31o_1
X_3532_ _0226_ _0232_ _0231_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__o21ai_1
X_3463_ net232 net128 net133 net226 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__nand4_4
XANTENNA__3225__B net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3394_ _2183_ _2304_ _2301_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a21bo_1
X_4015_ _0730_ _0732_ _0733_ _0724_ _0723_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o2111ai_4
XANTENNA_fanout179_A in2_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4917_ _1708_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__inv_2
XFILLER_52_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4848_ _1560_ _1562_ _1633_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__a22o_1
X_4779_ _1490_ _1493_ _1516_ _1523_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__o22ai_4
XFILLER_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4224__A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2501__Y _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3045__B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4463__A1 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2963_ net145 net236 VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nand2_1
X_4702_ _1472_ _1473_ _1474_ _1476_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__a31oi_1
XANTENNA__4323__C net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2894_ _2000_ _2002_ _2027_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__o21ai_2
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4633_ _1400_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__and2_1
X_4564_ _1323_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__nand2_1
X_3515_ _0203_ _0209_ _0213_ _0192_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__o211ai_2
X_4495_ _1243_ _1244_ _1201_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a21oi_1
X_3446_ _0146_ _0116_ _0145_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__nand3_4
X_3377_ _0078_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__inv_2
X_5047_ clknet_3_0__leaf_clk _0063_ VGND VGND VPWR VPWR in1_reg\[15\] sky130_fd_sc_hd__dfxtp_2
XFILLER_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout251_X net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone35 _2332_ _2368_ _2370_ _2473_ _2472_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__o2111ai_2
Xclone46 in1_reg\[11\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input24_A in2[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4440__A _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3300_ net247 net115 VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__nand2_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4280_ _1008_ _1009_ _1014_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nand3_1
X_3231_ _2353_ _2355_ _2352_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__o21bai_2
X_3162_ _2291_ _2292_ _2288_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__a21o_1
XANTENNA__4436__B2 _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3093_ _2119_ _2127_ _2222_ _2220_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_17_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3995_ _0705_ _0707_ _0709_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__nand3_4
X_2946_ _2076_ _2077_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__nand2_1
X_2877_ net258 net130 net121 net263 VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__a22oi_4
X_4616_ _1150_ _1152_ _1277_ _1278_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__nand4_4
XANTENNA_fanout211_A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2789__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4547_ net206 net96 VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__nand2_2
XANTENNA__4911__A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4478_ _1230_ _1232_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__nand2_1
X_3429_ net153 net202 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__nand2_1
XANTENNA__4525__A net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2989__B2 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3780_ net235 net108 _0490_ _0487_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a22oi_4
X_2800_ _1930_ _1924_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__nand2_1
XANTENNA__5039__Q in1_reg\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2731_ _1837_ _1838_ _1858_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_14_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4401_ _1009_ _1016_ _1145_ _1147_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nand4_1
X_2662_ _1793_ _1787_ _1783_ _1795_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__o211ai_2
XFILLER_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2593_ net260 net151 VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__nand2_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4332_ net211 net107 VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__nand2_2
X_4263_ _0997_ _0998_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__nand2_1
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_2
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
X_3214_ _2340_ _2343_ net82 _0504_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__o2bb2ai_1
X_4194_ _0793_ _0914_ _0913_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__o21ai_1
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3145_ _2058_ _2163_ _2271_ _2276_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__o31a_1
X_3076_ _2201_ _2113_ _2204_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__nand3_4
XFILLER_54_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout161_A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3978_ _0695_ _0696_ _0691_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_1
X_2929_ _1962_ _2059_ _1966_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__a21oi_2
XFILLER_10_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_68_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout74_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2503__A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput8 in1[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4950_ _0570_ net68 _1730_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__o21a_1
X_4881_ _1666_ _1667_ _1664_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__a21bo_1
X_3901_ _0488_ _0619_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3832_ _0536_ net288 _0511_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__and3_1
X_3763_ _0433_ _0463_ _0464_ _0431_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a31oi_2
X_3694_ _0343_ _0346_ _0396_ _0345_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__o211ai_4
X_2714_ net263 net258 in1_reg\[6\] net135 VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__and4_1
X_2645_ _1433_ _1466_ _1487_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__o21ai_4
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4315_ _1040_ _1045_ _1049_ _0904_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__a31oi_4
X_2576_ net162 net254 VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__nand2_1
X_4246_ _0963_ _0964_ _0971_ _0972_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__o2bb2ai_1
X_4177_ _0622_ _0904_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__or2_1
X_3128_ _2187_ _2188_ _2254_ _2256_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__o211ai_2
X_3059_ net253 net121 VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout164_X net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout77_X net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4432__B net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2504__Y _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3780__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4100_ net133 net203 VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__nand2_1
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4031_ _0748_ _0611_ _0746_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nand3_2
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4933_ net267 _1724_ _1726_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__and3_1
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4864_ net267 _1651_ _1652_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__and3_1
X_4795_ _1504_ _1505_ _1576_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a21o_1
X_3815_ _0278_ net216 net134 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__and3_1
XFILLER_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3746_ _0450_ _0452_ _0446_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__a21o_1
X_3677_ _0355_ _0356_ _0375_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__a21oi_1
X_2628_ _1358_ _1390_ _1763_ net274 VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__a31o_1
X_2559_ net174 net250 VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__nand2_1
X_4229_ _0956_ _0957_ _0961_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__nand3_2
XFILLER_46_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3421__B net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 in1[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_4580_ _1342_ _1344_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__nand2_1
Xinput22 in2[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_3600_ _0203_ _0209_ _0213_ _0192_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a2bb2oi_4
Xinput33 rst VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dlymetal6s2s_1
X_3531_ _2427_ _2464_ _2471_ _0228_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__o211ai_4
XFILLER_6_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5047__Q in1_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3462_ _0160_ _0161_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand2_2
X_3393_ _2406_ _0091_ _0092_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__nand3_2
XFILLER_69_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4014_ net307 _0732_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__o21ai_4
XFILLER_16_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4916_ _1700_ _1701_ _1706_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__o22ai_1
XFILLER_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout241_A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4847_ _1587_ _1631_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__nand2_1
X_4778_ _1490_ _1493_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__nor2_1
X_3729_ net148 net197 net191 net153 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a22o_2
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2538__A2 _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4463__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2962_ _2024_ _2022_ _2021_ _2005_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__a22oi_4
X_4701_ _1388_ _1475_ net273 VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a21o_1
XANTENNA__4323__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4632_ _1397_ _1399_ _0460_ net68 VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__o2bb2ai_1
X_2893_ _2021_ _2025_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__nand2_1
X_4563_ _1326_ _1192_ _1324_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__nand3_2
X_4494_ _0904_ _1198_ _1199_ _1246_ _1248_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__o2111ai_4
XPHY_EDGE_ROW_31_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3514_ _0190_ _0191_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o21ai_2
X_3445_ _0122_ _0124_ _0139_ _0141_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a22o_1
X_3376_ _2323_ _2479_ _0076_ _0077_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__nand4_4
XANTENNA__2701__A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5046_ clknet_3_0__leaf_clk _0062_ VGND VGND VPWR VPWR in1_reg\[14\] sky130_fd_sc_hd__dfxtp_2
XFILLER_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout244_X net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_A in2[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2506__A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4381__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4439__Y _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3230_ _2353_ _2355_ net236 net135 VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__o211a_1
X_3161_ net160 net154 net213 net208 VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__nand4_2
XFILLER_66_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3092_ _2107_ _2120_ _2011_ _2123_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA__5008__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3800__A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3994_ _0705_ _0707_ _0709_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__and3_1
X_2945_ net150 net232 net226 net155 VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__a22oi_1
X_2876_ net263 net122 VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__nand2_2
X_4615_ _1278_ _1148_ _1149_ _1276_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__a31oi_4
X_4546_ _1212_ _1306_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout204_A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4477_ _1229_ _1231_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__nor2_1
X_3428_ _0066_ _0128_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__nand2_1
XANTENNA_input9_A in1[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3359_ net149 net207 VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout194_X net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5029_ clknet_3_1__leaf_clk _0045_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfxtp_1
XANTENNA__4525__B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2507__Y _0526_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3929__A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2730_ _1839_ _1840_ _1856_ _1857_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__o211ai_1
XFILLER_12_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2661_ _1793_ _1787_ _1783_ _1795_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__o211a_2
X_4400_ _1009_ _1016_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nand2_1
XFILLER_8_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2592_ net255 net157 VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__nand2_1
X_4331_ net113 net204 VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__nand2_1
X_4262_ _0901_ _0996_ _0995_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__o21ai_1
Xfanout209 in2_reg\[10\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_6
X_3213_ net82 _0504_ _2339_ _2342_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__o22a_2
X_4193_ _0916_ _0919_ _0913_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a21o_1
X_3144_ _2058_ _2163_ _2271_ _2273_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__o211ai_1
XANTENNA__4048__D net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3075_ _2202_ _2203_ _2205_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_65_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout154_A net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3977_ _0434_ _0692_ _0691_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o211a_1
X_2928_ _2060_ _2061_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__nand2_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2859_ _1920_ _1937_ _1938_ _1931_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA_fanout207_X net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4529_ _1184_ _1185_ _1187_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_5_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4639__A2 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput9 in1[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4880_ _1667_ net176 net100 _1666_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__nand4_1
X_3900_ net240 net98 net92 net245 VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_62_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3831_ _0532_ _0533_ net288 _0511_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a22o_1
X_3762_ _0462_ _0457_ _0433_ _0464_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__o211ai_4
X_3693_ net278 _0347_ _0388_ _0389_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__o2bb2ai_4
X_2713_ net258 net135 VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__nand2_4
X_2644_ _1778_ _1780_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nand2_2
X_2575_ net162 net254 VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__and2_1
X_4314_ _0918_ _1047_ _1036_ _1039_ _1045_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__o221ai_2
X_4245_ _0978_ _0964_ _0963_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nand3_1
X_4176_ net239 net235 net91 net86 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__and4_4
XANTENNA_fanout271_A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3531__Y _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3127_ _2255_ _2253_ _2190_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__o21bai_4
XFILLER_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3058_ _2187_ _2188_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__or2_1
XFILLER_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4318__A1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4869__A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3154__B net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2514__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2568__B1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3532__A2 _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4030_ _0747_ _0745_ _0611_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__o21bai_4
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4932_ _1721_ _1722_ _1698_ _1695_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__o22ai_2
XFILLER_17_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4863_ _1646_ _1648_ _1642_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__o21bai_1
X_4794_ _1419_ _1503_ _1505_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__o211ai_2
X_3814_ net77 net73 _0275_ _0276_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__o22a_1
X_3745_ _0427_ net72 _0363_ _0451_ _0450_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_30_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout117_A in1_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3676_ _0355_ _0356_ _0374_ _0376_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a22o_1
X_2627_ _1097_ _1369_ _1761_ _1762_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__and4_1
X_2558_ net173 net250 VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__and2_1
X_4228_ _0956_ _0957_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout274_X net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4159_ _0603_ _0750_ _0751_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__and3_1
XFILLER_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3421__C net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4711__A1 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4724__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput12 in1[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XANTENNA__4950__A1 _0570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput23 in2[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
X_3530_ _0224_ _0225_ _0229_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__nand3_4
XANTENNA__3346__Y _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3461_ net231 net127 net133 net225 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a22oi_4
X_3392_ _2406_ _0091_ _0092_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and3_1
XANTENNA_clkbuf_3_6__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4013_ _0731_ _0730_ _0726_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__o21bai_4
XFILLER_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4915_ _1704_ _1705_ _0548_ net70 VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4846_ _1562_ _1565_ _1584_ _1631_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout234_A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4777_ _1489_ _1526_ _1528_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__a21oi_1
X_3728_ net148 net195 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nand2_1
X_3659_ _0130_ _0134_ _0132_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21oi_2
XFILLER_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4544__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4620__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3423__A1 net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2961_ _2001_ _2003_ _2020_ _2018_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__a22oi_2
XANTENNA__2631__C1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4700_ _1472_ _1473_ _1376_ _1378_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_63_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4631_ _1397_ _1399_ net125 net179 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__nand4_1
X_2892_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__inv_2
XFILLER_8_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4562_ _1299_ _1300_ _1320_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__o21ai_1
X_4493_ _1248_ _1200_ _1246_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__nand3_1
X_3513_ _0203_ _0209_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__o21ai_2
X_3444_ _0122_ _0124_ _0139_ _0141_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__nand4_2
XFILLER_69_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3375_ _2484_ _0073_ _0075_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__nand3_1
XFILLER_57_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5045_ clknet_3_2__leaf_clk _0061_ VGND VGND VPWR VPWR in1_reg\[13\] sky130_fd_sc_hd__dfxtp_4
XANTENNA_fanout184_A net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4829_ _1612_ _1605_ _1611_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout97_A in1_reg\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4381__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3160_ _2177_ _2289_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__nand2_1
X_3091_ _2210_ _2217_ _2218_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__nand3_1
XFILLER_66_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3993_ _0457_ _0466_ _0706_ _0704_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__o22ai_4
XFILLER_15_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2944_ net150 net232 VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__nand2_1
X_2875_ net253 net135 VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__nand2_1
X_4614_ _1148_ _1278_ _1149_ _1276_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__a31o_1
X_4545_ net204 net101 net96 net212 VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__a22oi_4
X_4476_ _1225_ _1228_ net131 net183 VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3427_ _2488_ _0065_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__nand2_1
X_3358_ net159 net202 VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__nand2_1
XFILLER_38_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout187_X net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3289_ net80 net74 _2413_ _2415_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__o211ai_1
X_5028_ clknet_3_1__leaf_clk _0044_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4060__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3874__A1 _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2517__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4435__C net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3929__A2 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2660_ _1477_ _1531_ _1787_ _1793_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA__4170__C net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2591_ _1238_ _1249_ _1227_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__a21boi_1
X_4330_ net118 net200 VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nand2_1
X_4261_ _0903_ _0994_ _0901_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o21ai_1
X_3212_ net264 net259 net109 net104 VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__nand4_1
X_4192_ _0916_ _0919_ _0913_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21oi_2
X_3143_ _2271_ _2273_ _2058_ _2163_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__o2bb2ai_2
X_3074_ _2111_ _2114_ _2113_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_65_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3976_ _0436_ _0693_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout147_A in1_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2927_ _1962_ _2057_ _2058_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__nand3b_1
X_2858_ _1986_ _1987_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__nand2_1
X_2789_ net255 net141 VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__and2_1
X_4528_ net216 net90 net85 net224 VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__a22oi_2
X_4459_ net210 net204 net107 net101 VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__nand4_2
XFILLER_49_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4727__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3830_ _0511_ net288 _0536_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_62_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3761_ _0468_ _0432_ _0467_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__nand3_2
X_2712_ _1789_ _1846_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__nand2_1
XFILLER_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3692_ _0390_ _0394_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand2_4
X_2643_ _1775_ _1776_ net168 net238 VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__nand4_4
X_2574_ _0922_ _1216_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__nand2_1
X_4313_ _1046_ _1048_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_2
XFILLER_19_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4244_ _0963_ _0964_ _0973_ _0976_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__o2bb2ai_2
X_4175_ net235 net86 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__nand2_4
X_3126_ _2253_ _2255_ _2190_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__o21ai_1
X_3057_ _2187_ _2188_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__nor2_1
XANTENNA__4372__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3959_ net127 net210 VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__nand2_2
XANTENNA__4318__A2 _0570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4547__A net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2530__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4176__B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4931_ _1696_ _1697_ _1723_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__nand3_1
X_4862_ _1638_ _1641_ _1646_ _1648_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__a211o_1
XFILLER_20_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3813_ _0512_ _0520_ _0522_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nand3_2
X_4793_ _1423_ _1573_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__o21ai_1
X_3744_ net140 net133 net211 net206 VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_30_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3675_ _0355_ _0356_ _0374_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nand4_1
X_2626_ _1358_ _1763_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__nor2_1
X_2557_ _1010_ _1042_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__nand2_1
X_4227_ _0827_ _0830_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__nand2_1
X_4158_ _0611_ _0749_ _0885_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__o21a_1
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4089_ _0784_ _0785_ _0809_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand4_2
XANTENNA_fanout267_X net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3109_ _2237_ _2236_ _2229_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__and3_1
XFILLER_70_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4711__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4427__D net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2525__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput13 in1[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput24 in2[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4950__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3460_ net230 net127 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__nand2_1
X_3391_ _0090_ _2405_ _0089_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__nand3_2
X_4012_ _0727_ _0729_ _0726_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o21ai_2
X_4914_ _1704_ _1705_ net94 net177 VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__and4_1
XFILLER_33_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4845_ _1629_ _1630_ _1588_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__o21a_1
X_4776_ net268 _1556_ _1557_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__and3_1
XANTENNA__3729__B1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3727_ _0284_ _0292_ _0289_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a21oi_4
X_3658_ _0130_ _0134_ _0132_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__a21o_1
X_3589_ _0189_ _0273_ _0282_ _0283_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a22oi_4
X_2609_ net162 net250 VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__nand2_1
XFILLER_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4544__B net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout190 in2_reg\[13\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_49_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3423__A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2960_ _2089_ _2091_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2891_ _2023_ _2006_ _2022_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__nand3_2
X_4630_ _1327_ _1396_ _1394_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__nand3_1
X_4561_ _1301_ _1318_ _1319_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_40_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4492_ _1195_ _1196_ _1245_ _1247_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__o22ai_2
X_3512_ _0208_ _0193_ _0207_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand3_4
X_3443_ _0121_ _0123_ _0139_ _0141_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__o211ai_2
XANTENNA__2698__B1 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3374_ _0073_ _0075_ _2484_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__a21o_1
X_5044_ clknet_3_0__leaf_clk _0060_ VGND VGND VPWR VPWR in1_reg\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout177_A net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4828_ net201 _1423_ net83 _1612_ _1611_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__a32o_1
XANTENNA_fanout132_X net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4759_ _0460_ net68 _1397_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_3_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3090_ _2209_ _2207_ _2219_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__a21oi_2
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3992_ _0457_ _0466_ _0704_ _0706_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_17_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2943_ net155 net226 VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__nand2_1
XANTENNA__4631__C net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2874_ net253 net135 VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__and2_4
X_4613_ _1379_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__nand2_1
X_4544_ net212 net96 VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__nand2_4
XANTENNA__4109__B1 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4475_ _1225_ _1228_ _1223_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__and3_1
X_3426_ _2490_ _2491_ _2488_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__a21oi_1
X_3357_ _0362_ net72 VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__nor2_1
X_5027_ clknet_3_1__leaf_clk _0043_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfxtp_1
X_3288_ _2413_ _2415_ _2410_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__a21o_1
XANTENNA__2607__B net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4060__A2 in1_reg\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3874__A2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input22_A in2[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3620__C net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2533__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4339__B1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4170__D in2_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3562__A1 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2590_ _1238_ _1249_ _1227_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__a21bo_1
X_4260_ _0903_ _0994_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nand2_2
X_4191_ _0916_ _0919_ net73 _0515_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__o2bb2ai_1
X_3211_ net264 net259 net108 net104 VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__and4_2
X_3142_ _2271_ _2273_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__nand2_1
X_3073_ _2113_ _2204_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3975_ net148 net142 net194 net190 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand4_1
X_2926_ _1962_ _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_28_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2857_ _1983_ _1989_ _1988_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__o21ai_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2788_ _1786_ _1849_ _1845_ _1847_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__o22a_1
X_4527_ net76 _0570_ _1034_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__or3_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4458_ net204 net101 VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_5_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3409_ _0106_ _2398_ _0105_ _2396_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__nand4_4
X_4389_ _1116_ _1117_ _1125_ _1126_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_37_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4536__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_46_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2595__A2 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4727__B net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2528__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3760_ _0468_ _0432_ _0467_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__and3_2
X_2711_ net257 net141 net136 net262 VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__a22oi_4
X_3691_ _0140_ _0126_ net309 _0383_ _0382_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o2111ai_4
X_2642_ _1775_ _1776_ net168 net238 VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__and4_1
XANTENNA__3535__B2 _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2573_ net266 net260 net157 net151 VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__nand4_2
X_4312_ _1040_ _1045_ _1049_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a21oi_1
X_4243_ _0969_ _0975_ _0974_ _0963_ _0964_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__o2111ai_4
X_4174_ _0816_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand2_1
XFILLER_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3125_ _2254_ _2256_ _2189_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__nand3_1
X_3056_ _2085_ _2091_ _2185_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__a21oi_2
XANTENNA__4653__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4372__B net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3958_ net138 net203 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__nand2_1
X_2909_ net171 net214 VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__and2_1
X_3889_ _0608_ _0607_ _0603_ _0602_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout212_X net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4547__B net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout72_A _0526_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4930_ _1721_ _1722_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__nor2_1
XFILLER_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4861_ _1555_ _1644_ _1648_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a21oi_1
X_3812_ _0512_ _0520_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nand2_1
X_4792_ _1503_ _1572_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__nand2_1
X_3743_ net133 net205 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nand2_2
XFILLER_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3674_ _0369_ _0364_ _0359_ _0368_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_30_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2625_ _1761_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__nand2_1
X_2556_ _1031_ _0911_ _1021_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand3_1
X_4226_ _0823_ _0826_ _0829_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__o21ai_2
X_4157_ _0611_ _0749_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__o21ai_2
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3108_ _2238_ _2239_ _2228_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__nand3_2
X_4088_ _0801_ _0804_ _0787_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_38_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3039_ _2142_ _2151_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__nand2_1
XFILLER_23_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4293__A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 in1[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput25 in2[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3390_ _0079_ _0084_ _0087_ _2477_ _2476_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__o2111ai_1
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4011_ _0470_ _0474_ _0727_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a21oi_2
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4913_ _1657_ _1658_ _1661_ _1654_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__nand4_1
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4844_ _1629_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__nor2_1
X_4775_ net298 _1551_ _1547_ _1555_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__o211ai_2
XANTENNA__3729__A1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3726_ _0292_ _0284_ _0288_ _0286_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o2bb2ai_1
XANTENNA_fanout122_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3657_ _0355_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nand2_1
X_3588_ _0274_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__nand2_1
X_2608_ net163 net168 net250 net243 VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__nand4_1
X_2539_ _0825_ net82 _0803_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__nor3_1
XFILLER_57_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4209_ _0938_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__nand2_1
XFILLER_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2640__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4393__A1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_4
XANTENNA__4294__Y _1034_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2890_ _2016_ _2008_ _2007_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__a21oi_1
XFILLER_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4560_ _1321_ _1317_ _1191_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__o211ai_4
XFILLER_8_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4491_ _1243_ _1244_ _1202_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__a21o_1
X_3511_ _0208_ _0193_ _0207_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__and3_1
X_3442_ _0142_ _0125_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__nand2_1
X_3373_ _0071_ _2485_ _0070_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__nand3_1
XANTENNA__2698__A1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5043_ clknet_3_1__leaf_clk _0059_ VGND VGND VPWR VPWR in1_reg\[11\] sky130_fd_sc_hd__dfxtp_2
XFILLER_40_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4827_ _1609_ _1610_ _0537_ _0559_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__o2bb2ai_1
XANTENNA_fanout125_X net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4758_ _0460_ net68 _1397_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__o21a_1
X_4689_ _1459_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__nand2_1
X_3709_ _0403_ _0405_ _0270_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21o_1
XFILLER_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4539__C net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3991_ _0457_ _0466_ _0705_ _0707_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__o211ai_2
X_2942_ net161 net220 VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4631__D net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2873_ _1849_ _1926_ _1929_ _1925_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__a22oi_4
X_4612_ _1270_ _1374_ _1375_ _1377_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__nand4_2
X_4543_ net107 net201 VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand2_1
X_4474_ net77 _0559_ _1224_ _1226_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__o22ai_2
X_3425_ _0122_ _0124_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__nand2_1
X_3356_ _2288_ _2292_ _2290_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_13_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3287_ _2413_ _2415_ net146 net219 VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__nand4_1
X_5026_ clknet_3_1__leaf_clk _0042_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2843__A1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout242_X net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3323__A2 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input15_A in1[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4190_ _0791_ _0917_ net217 net110 _0916_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o2111ai_1
X_3210_ in2_reg\[1\] net104 VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__nand2_2
X_3141_ _2269_ _2268_ _2267_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__nand3_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3072_ _2114_ _2111_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__nand2_4
XANTENNA__5021__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3974_ net148 net142 net193 net186 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__and4_1
XFILLER_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2925_ _2057_ _2058_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nand2_1
X_2856_ _1982_ _1984_ _1985_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__nand3_1
X_2787_ _1786_ _1849_ _1845_ _1847_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__o22ai_1
X_4526_ net224 net216 net90 net85 VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and4_2
XANTENNA_fanout202_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4457_ _1079_ _1209_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__nand2_2
XFILLER_49_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3408_ _2397_ _2403_ _0107_ _0109_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__o31a_1
X_4388_ _1118_ _1132_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__nand2_1
XANTENNA_input7_A in1[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3339_ _2465_ _2458_ _2428_ _2467_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__o211ai_2
X_5009_ clknet_3_7__leaf_clk _0025_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfxtp_1
XANTENNA__4536__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3359__B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2710_ net262 net135 VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__nand2_2
X_3690_ _0382_ _0383_ _0387_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__and3_1
X_2641_ net168 net238 _1775_ _1776_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__a22o_4
X_2572_ net266 net151 VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__nand2_1
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4311_ _1040_ _1045_ _1047_ _0918_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__o2bb2ai_1
X_4242_ _0969_ _0975_ _0974_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__o21ai_2
XANTENNA__4637__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4173_ _0817_ _0859_ _0861_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nand3_2
X_3124_ _2135_ _2251_ _2250_ _2249_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__o211ai_2
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3055_ _2185_ _2186_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__and2_1
XANTENNA__4653__B net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3471__A1 _0427_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout152_A in1_reg\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3957_ _0450_ _0445_ _0452_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_61_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2908_ _2032_ _2036_ _1971_ _2038_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__o211ai_2
X_3888_ _0602_ _0603_ _0607_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a22o_1
X_2839_ net155 net232 net226 net160 VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__a22o_1
XANTENNA_fanout205_X net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4509_ _1177_ _1178_ _1262_ _1263_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__a22o_1
XANTENNA__3732__B in1_reg\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_16_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3214__B2 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4860_ _1647_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__inv_2
X_3811_ _0512_ _0523_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__nand3b_4
X_4791_ net201 net83 VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__nand2_1
XFILLER_13_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3742_ _0366_ _0447_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nand2_2
X_3673_ _0369_ _0364_ _0359_ _0368_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_65_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2624_ _1075_ _1140_ _1735_ _1745_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__a2bb2o_1
X_2555_ net169 net254 _0933_ _0966_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a22o_1
XANTENNA__4469__B1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4225_ _0953_ _0954_ net126 net200 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand4_2
X_4156_ _0603_ _0751_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nand2_1
XFILLER_28_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3107_ _0406_ net75 _2233_ _2235_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__o211ai_2
X_4087_ _0807_ _0801_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nand2_1
X_3038_ _2061_ _2163_ _2168_ _2069_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_38_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4989_ clknet_3_7__leaf_clk _0005_ VGND VGND VPWR VPWR in2_reg\[5\] sky130_fd_sc_hd__dfxtp_4
XANTENNA_fanout68_X net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4293__B net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4632__B1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3435__A1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput26 in2[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput15 in1[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XANTENNA__3653__A net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4010_ _0430_ _0472_ _0728_ _0469_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a211oi_4
X_4912_ _1661_ _1659_ _1702_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4843_ _1626_ _1627_ _1620_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__and3_1
X_4774_ _1163_ _1551_ net298 _1547_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__a211o_1
XANTENNA__3729__A2 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3725_ _0374_ _0380_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout115_A net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3656_ net165 net185 _0352_ _0353_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__a22o_1
X_2607_ net162 net168 net250 net243 VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__and4_1
X_3587_ net134 net216 _0278_ _0280_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__a22o_1
X_2538_ net82 _0395_ _0803_ _0825_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__o22a_1
X_4208_ _0935_ _0937_ _0908_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout272_X net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4139_ _0816_ _0817_ _0859_ _0861_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__nand4_2
XFILLER_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2640__A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4393__A2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout181 net185 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_4
Xfanout192 in2_reg\[13\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
Xfanout170 net172 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_30_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3510_ _2445_ _2452_ _0204_ _0205_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__nand4_1
XANTENNA__2702__D net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4490_ _1243_ _1244_ _1202_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a21oi_1
X_3441_ _0139_ _0141_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__nand2_1
X_3372_ _0071_ _2485_ _0070_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__and3_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2698__A2 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5042_ clknet_3_0__leaf_clk _0058_ VGND VGND VPWR VPWR in1_reg\[10\] sky130_fd_sc_hd__dfxtp_4
XFILLER_18_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout232_A net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4826_ _1610_ net181 net101 _1609_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__nand4_4
XANTENNA__3558__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone29 _1875_ _1957_ _1960_ _1958_ VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__nand4_2
X_4757_ _1481_ _1532_ _1533_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nand3_1
X_4688_ _1461_ _1393_ _1460_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__nand3_2
X_3708_ _0403_ _0405_ _0270_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand3_4
X_3639_ _0335_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nand2_4
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4539__D net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__3810__A1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3990_ _0704_ _0706_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__o21ai_4
X_2941_ _1999_ _1995_ _1996_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__a21oi_2
XFILLER_62_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4611_ _1372_ _1373_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nand3_2
X_2872_ _1849_ _1926_ _1929_ _1925_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__a22o_1
X_4542_ _1208_ _1213_ _1210_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a21oi_1
X_4473_ _1225_ _1228_ _1223_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a21oi_1
X_3424_ _0121_ _0123_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nor2_1
X_3355_ _2288_ _2292_ _2290_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__a21o_1
X_3286_ net80 net74 _2412_ _2414_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__o22ai_1
X_5025_ clknet_3_1__leaf_clk _0041_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout182_A net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2607__D net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout235_X net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4809_ _1485_ net176 net118 _1483_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout95_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__3562__A3 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _2149_ _2264_ _2270_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__a21oi_2
XFILLER_67_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3071_ _2198_ _2191_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__nand2_1
XFILLER_54_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3973_ net142 net194 VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ _1970_ _2054_ _2055_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__nand3_4
X_2855_ _1984_ _1985_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__nand2_1
X_4525_ net216 net85 VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__nand2_1
X_2786_ _1789_ _1846_ _1845_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__a21oi_2
X_4456_ net204 net107 net101 net210 VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3407_ net273 _0108_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__nor2_1
X_4387_ _1116_ _1117_ _1131_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__a21oi_1
X_3338_ _2428_ _2467_ VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__nand2_1
X_3269_ _2167_ _2274_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__nor2_2
XANTENNA_fanout185_X net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5008_ clknet_3_7__leaf_clk _0024_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfxtp_1
XFILLER_26_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3168__D net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2640_ net168 net238 _1775_ _1776_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__a22oi_2
X_2571_ _0966_ _1194_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__nand2_1
X_4310_ _1038_ _0905_ _1037_ _1049_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a31o_1
X_4241_ _0970_ net183 net143 _0968_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__and4_1
X_4172_ _0899_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nand2_1
XANTENNA__4637__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3123_ _2135_ _2251_ _2249_ net319 VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__o211a_1
X_3054_ _2086_ _2087_ _2085_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__a21boi_1
XANTENNA__3471__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3956_ _0446_ _0448_ _0452_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_61_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2907_ _2032_ _2036_ _1971_ _2038_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__o211a_1
X_3887_ _0254_ _0422_ _0421_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a21bo_4
X_2838_ net154 net232 net226 net161 VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__a22oi_2
X_2769_ _1899_ _1900_ _1823_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__and3_1
X_4508_ _1177_ _1178_ _1262_ _1263_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nand4_1
X_4439_ _1182_ _1188_ _1189_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__nand3_4
XANTENNA__3732__C net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2973__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4650__B2 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4650__A1 net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4790_ net201 net89 VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__nand2_1
X_3810_ _0460_ net73 _0518_ _0519_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__o211ai_2
XFILLER_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3741_ net134 net211 net205 net140 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a22oi_4
XFILLER_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3672_ _0371_ _0358_ _0370_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand3_2
X_2623_ _1162_ _1756_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__or2_1
X_2554_ _0966_ net254 net169 _0933_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand4_1
XANTENNA__4469__B2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4469__A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4224_ net126 net200 _0953_ _0954_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a22o_1
X_4155_ _0882_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nand2_1
X_3106_ _2233_ _2235_ _2230_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__a21o_1
X_4086_ _0787_ _0801_ _0802_ _0796_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__o2bb2ai_2
X_3037_ _2063_ _2065_ _2066_ _2168_ _2169_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__o41a_1
XFILLER_36_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4988_ clknet_3_6__leaf_clk _0004_ VGND VGND VPWR VPWR in2_reg\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_X net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3939_ _0652_ _0653_ _0656_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and3_1
XFILLER_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3743__B net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3435__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4632__B2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 in2[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput16 in1[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4911_ _1653_ net182 net95 _1654_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__a31o_1
XFILLER_33_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4842_ _1626_ _1627_ _1620_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__a21oi_1
X_4773_ _1157_ _1160_ _1552_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nand3_2
XFILLER_20_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3724_ _0355_ _0356_ _0374_ _0375_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a31o_1
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3655_ _0352_ _0353_ net165 net182 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__nand4_2
X_2606_ net162 net243 VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__nand2_1
X_3586_ _0278_ _0280_ net134 net216 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__and4_1
X_2537_ net256 net173 VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nand2_1
X_4207_ _0935_ _0908_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nand2_2
X_4138_ _0816_ _0817_ _0857_ _0860_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__o2bb2ai_1
X_4069_ net217 net114 VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
XANTENNA__4378__B1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3738__B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout80_X net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_1
Xfanout182 net185 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_4
XANTENNA__3656__A2 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_6
Xfanout193 net199 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_4
XFILLER_15_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3440_ _0135_ _0136_ _0129_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__nand3_2
X_3371_ _2486_ _0068_ _0069_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__nand3_2
X_5041_ clknet_3_0__leaf_clk _0057_ VGND VGND VPWR VPWR in1_reg\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4825_ net94 net186 net88 net194 VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a22o_1
X_4756_ _1482_ _1534_ _1535_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__nand3_2
XANTENNA__3583__A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout225_A net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4687_ _1403_ _1456_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__nand2_1
X_3707_ _0403_ _0405_ _0270_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__and3_1
X_3638_ _0337_ _0299_ _0336_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__nand3_4
X_3569_ _0148_ _0262_ _0263_ _0261_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone1 _1549_ _1471_ _1548_ _1384_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_3_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3810__A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4771__B1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkload3_A clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2940_ _1991_ _2032_ _2034_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__o21ai_1
X_2871_ _2001_ _2003_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__nand2_1
X_4610_ _1168_ _1264_ _1265_ _1269_ _1273_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a32o_1
X_4541_ _1208_ _1213_ _1210_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__a21o_1
X_4472_ net125 net119 net195 net188 VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__nand4_1
X_3423_ net170 net182 _0119_ _0120_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__a22o_1
X_3354_ _2483_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__inv_2
X_3285_ net140 net231 net136 net225 VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__nand4_4
X_5024_ clknet_3_1__leaf_clk _0040_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout175_A in1_reg\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4808_ _1528_ _1530_ _1587_ _1589_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__o22ai_2
X_4739_ _1512_ _1513_ _1286_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_8_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3661__B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3070_ net81 _0493_ _2112_ _2196_ _2195_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__o221ai_2
XANTENNA__4773__A net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3972_ net142 net189 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nand2_1
X_2923_ _2052_ _2053_ _1969_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__nand3_1
X_2854_ _1982_ _1984_ _1985_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__a21o_1
X_2785_ _1918_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__nor2_2
X_4524_ _1262_ _1266_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__nand2_1
XANTENNA__4948__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4455_ net210 net101 VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand2_2
XFILLER_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3406_ _2397_ _2403_ _0105_ _0106_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__o211a_1
X_4386_ _1116_ _1117_ _1132_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a21o_1
X_3337_ _2457_ _2459_ _2438_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__a21o_1
X_3268_ _2395_ _2397_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_56_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5007_ clknet_3_7__leaf_clk _0023_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout178_X net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3199_ _2322_ _2324_ _2326_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_64_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input20_A in2[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2841__A net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2570_ _0373_ _0384_ _0933_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__o21ai_1
X_4240_ net137 net132 net196 net189 _0965_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__a41o_1
X_4171_ _0896_ _0898_ _0417_ net70 VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__o2bb2ai_1
X_3122_ _2249_ _2250_ _2252_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__a21o_1
XFILLER_55_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3053_ _2182_ _2184_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__nand2_2
XFILLER_67_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3955_ _0543_ _0511_ _0668_ net294 VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nand4_4
X_2906_ _2037_ _2038_ _1971_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout138_A in1_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3886_ _0110_ _2402_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__o21ai_4
X_2837_ _1907_ _1946_ _1948_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__o21ai_2
X_2768_ _1899_ _1823_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__nand2_1
X_4507_ _1181_ _1263_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__nand2_1
X_2699_ net250 net151 net243 net158 VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__a22o_1
X_4438_ _1188_ _1189_ _1182_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__a21o_1
X_4369_ _1107_ _1111_ _1112_ _0945_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA__3732__D net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2926__A net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2973__A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4100__B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_1__f_clk_X clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4938__B1 net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3740_ net133 net211 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nand2_2
X_3671_ _0371_ _0358_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and3_1
XANTENNA__4769__Y net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2622_ _1735_ _1745_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__nand2_1
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ _0911_ _0988_ _0999_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__nand3b_1
XANTENNA__2716__A2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4469__A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4223_ _0460_ net71 _0953_ _0954_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o211ai_1
X_4154_ _0755_ _0743_ _0878_ _0881_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o22ai_2
X_4085_ _0797_ _0795_ _0789_ _0787_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__a31oi_2
X_3105_ _2235_ net220 net155 _2233_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__nand4_1
X_3036_ _2069_ _2168_ net274 VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__a21oi_1
X_4987_ clknet_3_6__leaf_clk _0003_ VGND VGND VPWR VPWR in2_reg\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3938_ _0654_ _0655_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__nand2_1
X_3869_ _0565_ _0566_ _0578_ _0579_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_72_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput28 in2[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput17 in2[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_28_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4910_ net186 net88 net180 net83 VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_35_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4841_ _1624_ _1625_ net106 net176 VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__nand4_1
XFILLER_33_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4772_ _1159_ _1550_ _1158_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__nor3_2
XFILLER_9_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3723_ _0343_ _0346_ _0396_ net284 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a2bb2oi_2
X_3654_ _0352_ _0353_ net165 net182 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__and4_1
X_2605_ net173 net238 VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__nand2_1
X_3585_ net230 net128 net224 net123 _0281_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a41o_1
X_2536_ net164 net265 net261 net169 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a22oi_2
X_4206_ _0905_ _0907_ _0932_ _0934_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__o211ai_4
X_4137_ _0816_ _0817_ _0855_ _0856_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o2bb2ai_1
X_4068_ _0618_ _0623_ _0620_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a21oi_2
XFILLER_73_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3019_ _2149_ _2150_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__nand2_1
XFILLER_24_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout160_X net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2642__C net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4550__A1 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4866__A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout172 in1_reg\[0\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_2
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_2
XANTENNA_fanout73_X net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout150 net152 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net164 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_6
Xfanout194 net199 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_15_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3370_ _2486_ _0068_ _0069_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and3_1
XANTENNA__4776__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5040_ clknet_3_4__leaf_clk _0056_ VGND VGND VPWR VPWR in1_reg\[8\] sky130_fd_sc_hd__dfxtp_2
XFILLER_65_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5024__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4824_ net194 net94 net186 net88 VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand4_2
X_4755_ _1489_ _1529_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout120_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3855__A _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3583__A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3706_ _0410_ _0260_ _0409_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nand3_4
X_4686_ _1400_ _1401_ _1453_ _1454_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout218_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3637_ _0307_ _0309_ _0329_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__o21ai_2
X_3568_ _0395_ net70 _0264_ _0266_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__a2bb2oi_2
X_2519_ net272 net28 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__and2_1
XFILLER_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3499_ net259 net93 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nand2_2
XANTENNA__2846__A1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone2 _0110_ _2402_ _0606_ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_54_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2828__B net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2870_ _2001_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__and2_1
X_4540_ _1299_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nor2_1
X_4471_ net125 net119 net195 net188 VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__and4_2
XFILLER_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3422_ _0119_ _0120_ _0395_ _0559_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o2bb2a_1
X_3353_ net165 net192 _2285_ _2482_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__a31o_1
X_3284_ _2316_ _2411_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__nor2_1
X_5023_ clknet_3_4__leaf_clk _0039_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout168_A in1_reg\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4807_ _1558_ _1588_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2999_ _2126_ _2107_ _2095_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__a21oi_2
X_4738_ _1515_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__inv_2
X_4669_ _1437_ _1291_ _1436_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_8_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3971_ net153 net184 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__and2_1
X_2922_ _2054_ _2055_ _1970_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_13_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2853_ _1985_ _1984_ _1982_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__nand3b_1
XANTENNA__3538__A2 _0232_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2784_ net80 _1916_ _1912_ _1915_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__o211a_1
X_4523_ _1181_ _1263_ _1262_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a21boi_2
X_4454_ net113 net200 VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nand2_1
X_4385_ _1116_ _1117_ _1127_ _1130_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nand4_1
X_3405_ _0105_ _0106_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__and2_1
X_3336_ _2457_ _2459_ _2438_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__and3_1
XANTENNA__4964__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5006_ clknet_3_7__leaf_clk _0022_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfxtp_1
X_3267_ _2268_ _2393_ _2394_ net302 VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__nand4_1
XFILLER_73_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3198_ _2234_ _2230_ _2233_ _2323_ _2325_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_56_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3226__A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__3465__D net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input13_A in1[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4414__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4114__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4170_ _0896_ _0898_ net148 in2_reg\[15\] VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand4_1
X_3121_ _2249_ _2250_ _2252_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__a21oi_4
XFILLER_48_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3052_ _2180_ _2181_ _2144_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__o21ai_4
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3954_ _0506_ _0509_ _0543_ _0668_ net292 VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o2111a_1
X_3885_ _0104_ _0111_ _0605_ _0421_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__o211a_1
X_2905_ _1946_ _1950_ _2037_ _2038_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__a2bb2oi_4
X_2836_ _1955_ _1958_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__nand2_2
X_2767_ _1899_ _1900_ _1823_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__a21o_1
X_4506_ _1179_ _1180_ _1262_ _1263_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout200_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2698_ net251 net151 net244 net158 VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__a22oi_1
X_4437_ _1186_ _1187_ net217 net97 VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__nand4_2
X_4368_ _1107_ _1111_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a21oi_1
XANTENNA_input5_A in1[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4299_ _1038_ _0905_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout190_X net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3319_ _2445_ _2447_ net256 net108 VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__and4_1
XFILLER_26_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer40 _0338_ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_25_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2942__A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4588__B net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3670_ _0365_ _0367_ _0360_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a21o_1
X_2621_ _1671_ _1682_ _1725_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__nand3_1
X_2552_ _0933_ _0966_ _0977_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__a21o_1
XFILLER_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4222_ _0953_ _0954_ _0950_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_34_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4153_ _0881_ _0756_ _0879_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__nand3b_4
X_4084_ _0638_ _0644_ _0801_ _0804_ _0642_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__o2111ai_2
X_3104_ _2233_ _2235_ _0406_ net75 VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__o2bb2ai_1
X_3035_ _2166_ _2165_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_43_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4986_ clknet_3_4__leaf_clk _0002_ VGND VGND VPWR VPWR in2_reg\[2\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_fanout150_A net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3937_ _0652_ _0653_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a21oi_1
XANTENNA_fanout248_A net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3868_ _0582_ _0583_ _0565_ net276 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__o211ai_2
X_2819_ _1901_ _1904_ _1949_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__o21ai_1
XFILLER_11_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3799_ _0301_ _0306_ _0303_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a21oi_4
XANTENNA_fanout203_X net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 in2[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
Xinput29 in2[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_70_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3653__D net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2566__B net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4840_ net106 net176 _1624_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__a22o_1
XFILLER_33_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4771_ _1154_ _0887_ _1550_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__a21oi_1
X_3722_ _0396_ net285 _0343_ _0346_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__o2bb2ai_4
X_3653_ net159 net153 net198 net191 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nand4_2
X_2604_ _1542_ _1553_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__nand2_1
X_3584_ _0274_ _0282_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__nand3b_4
X_2535_ net164 net265 net261 net169 VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__nand4_1
XANTENNA__2570__A1 _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4205_ _0923_ _0927_ _0931_ _0926_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__o211ai_1
XANTENNA__3860__B net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4136_ _0862_ _0817_ _0816_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout198_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4067_ _0618_ _0623_ _0620_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
X_3018_ _2149_ _2150_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__and2_1
XFILLER_24_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4969_ net269 net8 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_1
XANTENNA__2642__D net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4550__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_6
Xfanout173 net175 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_4
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_4
Xfanout195 net199 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_4
Xfanout184 net185 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_8
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4823_ net194 net88 VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__nand2_1
X_4754_ _1486_ _1488_ _1526_ _1527_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand4_1
XANTENNA__3855__B net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3705_ _0403_ _0405_ _0271_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a21o_1
X_4685_ _1343_ _1392_ _1457_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__o211ai_4
XANTENNA_fanout113_A in1_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3636_ _0308_ _0310_ _0327_ _0328_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nand4_2
X_3567_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_2518_ net270 net27 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__and2_1
X_3498_ _2446_ _0197_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__nand2_4
XFILLER_56_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2846__A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4119_ _0835_ _0837_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21boi_2
Xclone3 _1549_ _1471_ _1548_ _1384_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__o22ai_2
XANTENNA__2493__Y _0373_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4986__CLK clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2860__A _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4470_ net119 net195 net188 net125 VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__a22o_1
X_3421_ _0120_ net182 net170 _0119_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__nand4_2
X_3352_ net167 net198 net192 net170 VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__a22oi_1
X_3283_ _2316_ _2411_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__nand2_1
X_5022_ clknet_3_1__leaf_clk _0038_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4806_ _1562_ _1565_ _1584_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout230_A in2_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2998_ _2101_ _2102_ net67 _2124_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__o22ai_2
X_4737_ _1513_ _1286_ _1512_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__nand3_4
X_4668_ _1438_ _1429_ _1293_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__o211ai_4
X_3619_ net259 net87 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4599_ _1284_ _1361_ _1363_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__nand3_2
XFILLER_0_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2830__D net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3970_ _0686_ _0687_ _0676_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__nand3_4
XFILLER_62_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2921_ _2040_ _2042_ _2050_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__nand3_2
X_2852_ _1982_ _1984_ _1985_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_13_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2783_ net158 net237 _1915_ _1917_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__a22oi_2
X_4522_ _1277_ _1278_ _1280_ _1281_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__a31oi_1
X_4453_ net113 net200 VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__and2_1
X_3404_ _0102_ _0103_ _2281_ _2391_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o2bb2ai_2
X_4384_ _1125_ _1126_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nand2_1
X_3335_ _2459_ _2438_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__nand2_1
XFILLER_58_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3266_ _2272_ _2393_ _2394_ _2268_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__and4_1
X_5005_ clknet_3_5__leaf_clk _0021_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfxtp_1
X_3197_ _2323_ _2325_ _2326_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_56_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4980__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3226__A2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout233_X net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout93_A in1_reg\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2841__C net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3120_ _2132_ _2128_ _2093_ _2134_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__a22oi_4
XANTENNA__4102__B1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3051_ _2180_ _2181_ net166 net208 _2043_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__o2111a_1
X_3953_ _0542_ _0510_ _0669_ _0667_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__o22ai_4
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3884_ _0255_ _0418_ _0420_ _0253_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand4_1
X_2904_ _2035_ _1991_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__nand2_1
X_2835_ _1956_ _1828_ _1955_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__a21boi_1
X_2766_ _1899_ _1900_ _1823_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__a21oi_1
X_4505_ _1179_ _1180_ _1262_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__a22o_1
X_2697_ net163 net238 VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__nand2_1
X_4436_ net217 net97 _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__a22o_1
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4975__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4367_ _0948_ _0989_ _0990_ _0945_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_69_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3318_ _2445_ _2447_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__nand2_1
X_4298_ _1032_ _1035_ net73 _0537_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_58_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3249_ _2305_ _2307_ _2378_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__o21ai_1
XFILLER_73_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer30 _0730_ VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_6
Xrebuffer41 _0591_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__buf_1
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout96_X net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2620_ _1714_ _1703_ _1692_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__nand3_1
X_2551_ _0373_ _0384_ _0933_ _0966_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__o211ai_1
X_4221_ net119 net210 net114 net204 VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nand4_4
XFILLER_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4152_ _0877_ _0875_ _0758_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a21oi_4
X_4083_ _0801_ _0804_ _0787_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a21o_1
X_3103_ _2231_ _2232_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__nand2_2
X_3034_ _2161_ _2158_ _2160_ _2164_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__o211ai_1
XFILLER_55_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4985_ clknet_3_4__leaf_clk _0001_ VGND VGND VPWR VPWR in2_reg\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_51_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout143_A in1_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3936_ _0460_ net73 _0517_ _0519_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_21_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3867_ _0565_ _0566_ _0582_ _0583_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__o2bb2ai_1
X_2818_ _1902_ _1905_ _1947_ _1948_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__nand4_1
X_3798_ _0327_ _0503_ _0505_ _0507_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand4_4
X_2749_ _1817_ _1884_ net274 VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__a21oi_1
X_4419_ _0449_ net69 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__nor2_1
XANTENNA__4865__B2 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4865__A1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2496__Y _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4617__A1 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2628__B1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 in2[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_69_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4856__A1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3044__B1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4770_ _1548_ _1385_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__nor2_4
X_3721_ _0245_ _0411_ _0412_ _0415_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__o2bb2ai_2
X_3652_ _0118_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_21_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3583_ net73 net77 _0278_ _0280_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__o211ai_4
X_2603_ _1531_ _1466_ _1422_ _1520_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__o211ai_4
X_2534_ net164 net265 net261 net169 VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__and4_1
XANTENNA__2757__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4204_ _0926_ _0928_ _0931_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and3_2
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4135_ _0859_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__nand2_1
XFILLER_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4066_ net217 _0642_ net120 _0644_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a31o_1
XFILLER_24_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3017_ _2144_ _2145_ _2147_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4968_ net269 net1 VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__and2_1
XFILLER_11_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4899_ _1688_ _1689_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__nor2_1
X_3919_ net222 net114 VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
XFILLER_22_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_2__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4535__B1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4866__C net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout130 in1_reg\[8\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_4
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout152 in1_reg\[4\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_6
Xfanout141 in1_reg\[6\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_8
Xfanout163 net164 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
Xfanout196 net199 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__buf_2
Xfanout185 in2_reg\[14\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_4
XFILLER_63_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4774__B1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3577__B2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4822_ net94 net186 VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4753_ _1486_ _1488_ _1529_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__nand3_1
X_3704_ _0271_ _0403_ _0405_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nand3_2
X_4684_ _1456_ _1402_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__nand2_1
X_3635_ _0326_ _0330_ _0300_ _0332_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__o211ai_4
X_3566_ _0262_ _0152_ _0147_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__nand3b_2
X_2517_ net272 net26 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__and2_1
X_3497_ net259 net98 net92 net264 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a22oi_1
XANTENNA__4983__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4118_ _0841_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nand2_2
X_4049_ _0766_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__nand2_2
XFILLER_56_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2653__D net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2860__B net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3972__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4787__B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3420_ _0120_ net182 net170 _0119_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__and4_2
X_3351_ net167 net170 net197 net191 VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand4_2
X_3282_ net231 net133 net225 net140 VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__a22oi_4
X_5021_ clknet_3_1__leaf_clk _0037_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4805_ _1562_ _1565_ _1584_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__a21oi_1
X_2997_ _2103_ _2105_ _2120_ _2125_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__o211ai_2
X_4736_ _1512_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout223_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4667_ _1430_ _1432_ _1414_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__a21o_1
XANTENNA__4978__A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3618_ _0200_ _0316_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_8_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4598_ _1342_ _1344_ _1360_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a21o_1
X_3549_ _0238_ _0241_ _0247_ _0240_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_67_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2920_ _2039_ _2041_ _2050_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__o21bai_2
X_2851_ _1822_ _1892_ _1894_ _1891_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_13_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2782_ net249 net152 net242 net145 VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__nand4_2
X_4521_ _1152_ _1164_ _1279_ net273 VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__a31o_1
XFILLER_7_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4452_ _0951_ _1079_ _1073_ _1077_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__o22a_1
X_3403_ _0103_ _2392_ _0102_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__nand3_1
X_4383_ _1127_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__nand2_1
X_3334_ _2460_ _2462_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__nor2_1
XFILLER_58_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3265_ _2272_ _2268_ _2393_ _2394_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__a22o_1
X_5004_ clknet_3_5__leaf_clk _0020_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3196_ _2324_ _2322_ _2326_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_56_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2985__A2 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout226_X net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4719_ _1491_ _1492_ _0504_ _0559_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout86_A in1_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2841__D net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4178__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4102__A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3050_ _2176_ _2179_ _2181_ _2144_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__a211o_1
XFILLER_63_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3952_ net275 _0543_ _0668_ net303 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_61_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3883_ _0602_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nand2_2
X_2903_ _1992_ _2033_ _2034_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__nand3_1
X_2834_ net272 _1967_ _1968_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__and3_1
X_2765_ _1895_ _1896_ _1890_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__nand3_2
X_4504_ _1061_ _1250_ _1251_ _1259_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__nand4_4
X_2696_ _1796_ _1781_ _1798_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__a21oi_4
X_4435_ net228 net222 net93 net86 VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand4_4
X_4366_ _0948_ _0989_ _0990_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_69_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3317_ net264 net259 net104 net99 VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__nand4_4
XFILLER_58_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4297_ _1032_ _1035_ net217 net102 VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__nand4_4
XFILLER_73_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3248_ _2306_ _2308_ _2376_ _2377_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__nand4_2
XFILLER_73_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer20 _0670_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_6
X_3179_ _2248_ _2225_ net310 _2226_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__o2bb2ai_4
Xrebuffer31 _0546_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_2
Xrebuffer42 _2250_ VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__buf_2
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3080__A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4231__A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2686__A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2550_ net169 net254 VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__nand2_1
X_4220_ _0828_ _0951_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand2_1
X_4151_ _0731_ _0757_ _0875_ _0877_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o211ai_2
XANTENNA__2885__B2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4082_ _0789_ _0795_ _0797_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand3_2
X_3102_ net145 net231 net225 net149 VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__a22oi_1
X_3033_ _2161_ _2158_ _2160_ _2164_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__o211a_1
XANTENNA__5027__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4984_ clknet_3_5__leaf_clk _0000_ VGND VGND VPWR VPWR in2_reg\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3935_ _0513_ _0517_ _0519_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__o21ai_4
XFILLER_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3866_ _0565_ _0566_ _0582_ _0583_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__o2bb2a_1
XANTENNA_fanout136_A in1_reg\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2817_ _1949_ _1906_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__nand2_1
X_3797_ _0327_ _0503_ _0505_ _0507_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and4_1
X_2748_ _1882_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__nand2_1
X_4418_ _1116_ _1131_ _1117_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__a21boi_1
XANTENNA__3890__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2679_ _1809_ _1810_ _1813_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__nand3_2
XANTENNA__4865__A2 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4349_ _0923_ _0927_ _0930_ _0926_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4553__A1 _0515_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2867__A1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4781__D net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4407__Y net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3044__A1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3975__A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3720_ _0424_ _0425_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__nor2_1
X_3651_ net156 net197 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nand2_1
X_3582_ _0278_ _0280_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a21o_1
X_2602_ _1509_ _1411_ _1498_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__nand3_2
XFILLER_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2533_ net271 _0771_ _0782_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__and3_1
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4203_ _0929_ _0930_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nand2_1
X_4134_ _0844_ _0850_ _0818_ _0854_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__o211ai_2
XFILLER_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4065_ _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nand2_1
X_3016_ _1982_ _1989_ _2144_ _2145_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__a211o_1
XFILLER_24_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4967_ _1758_ _1760_ net273 VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__a21oi_1
X_4898_ _1640_ _1687_ net273 VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__o21bai_1
X_3918_ net218 net120 VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__and2_1
X_3849_ net159 net156 net197 net191 _0354_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a41o_1
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_6
Xfanout120 net124 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
Xfanout142 in1_reg\[5\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout153 net156 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout164 in1_reg\[2\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_4
Xfanout175 in1_reg\[0\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_2
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_2
Xfanout197 net199 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2964__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3577__A2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3734__C1 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2593__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4821_ _1423_ net84 net201 VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__and3_1
X_4752_ _1489_ _1526_ _1527_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nand3_1
XFILLER_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4683_ _1449_ _1452_ _1454_ _1403_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__o211ai_2
X_3703_ _0397_ _0398_ _0237_ _0270_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a31o_1
X_3634_ _0330_ _0326_ _0300_ _0332_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o211a_1
X_3565_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3496_ net264 net92 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nand2_2
X_2516_ net271 net25 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__and2_1
XFILLER_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4117_ _0839_ _0840_ _0417_ _0559_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__o2bb2ai_2
X_4048_ _0765_ net153 _0764_ net177 VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__nand4_2
XANTENNA__3886__Y net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout71_X net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input29_A in2[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3350_ _2323_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__nand2_1
X_5020_ clknet_3_1__leaf_clk _0036_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfxtp_1
X_3281_ net231 net136 VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__nand2_1
XFILLER_65_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4324__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4804_ _1562_ _1565_ _1584_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__nand3_1
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2749__B1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4735_ _1493_ _1495_ _1507_ _1510_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__o22ai_4
X_2996_ _2103_ _2105_ net67 _2124_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__o22ai_2
X_4666_ _1414_ _1432_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout216_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4597_ _1353_ _1355_ _1356_ _1344_ _1342_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__o2111ai_4
X_3617_ net259 net92 net87 net265 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a22oi_4
XANTENNA__2779__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3548_ _0245_ _0246_ _0243_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o21ai_2
X_3479_ _2439_ _2459_ _2449_ _2456_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_59_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_4__f_clk_X clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2850_ _1978_ _1979_ _1981_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_13_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2781_ net249 net151 net242 VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__nand3_1
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4520_ _1152_ _1164_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__nand2_1
X_4451_ _1073_ _1077_ _1080_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__o21ai_1
X_3402_ _0102_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nand2_1
X_4382_ net80 net69 _1122_ _1124_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__o211ai_1
XANTENNA__2927__A_N net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3333_ _2436_ _2437_ _2457_ _2459_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ _2272_ _2268_ _2394_ _2393_ VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__a22oi_1
X_5003_ clknet_3_5__leaf_clk _0019_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfxtp_1
XANTENNA__3223__A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3195_ _2230_ _2234_ _2233_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_56_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout166_A net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2781__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4054__A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2979_ net262 net116 VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__nand2_2
X_4718_ _1492_ net181 net112 _1491_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout219_X net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4649_ net212 net89 VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__nand2_1
XFILLER_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3622__B2 _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4114__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3951_ _0667_ _0669_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nor2_1
XFILLER_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2902_ _1992_ _2034_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__nand2_1
X_3882_ _0426_ _0598_ _0599_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nand3_2
XFILLER_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2833_ _1964_ _1965_ _1886_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__nand3_4
X_2764_ _1890_ _1897_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__nand3b_2
X_4503_ _1062_ _1252_ _1258_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__nand4_4
X_2695_ _1792_ _1782_ _1791_ _1780_ _1778_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__a32oi_4
X_4434_ net222 net91 net86 net228 VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a22o_1
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4365_ _0985_ _0987_ _0947_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__a21oi_1
X_3316_ net259 net98 VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_69_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4296_ _1032_ _1035_ net217 net102 VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__and4_1
XANTENNA__3301__B1 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3247_ _2376_ _2377_ VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__nand2_1
Xrebuffer21 _1155_ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
Xrebuffer10 _0345_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_2
XFILLER_54_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3178_ _2306_ _2308_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__nand2_1
Xrebuffer43 _0221_ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_2
Xrebuffer32 _0139_ VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_2
XFILLER_54_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2967__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2686__B net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input11_A in1[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4150_ _0731_ _0757_ _0875_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__o211a_1
X_3101_ net149 net145 net231 net225 VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__nand4_4
X_4081_ _0789_ _0795_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand2_1
X_3032_ _2160_ _2162_ _2164_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4983_ net268 net7 VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__and2_1
X_3934_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nand2_1
X_3865_ _0578_ _0579_ _0565_ _0566_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__o211ai_2
X_2816_ _1901_ _1904_ _1947_ _1948_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_21_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3796_ _0312_ _0327_ _0328_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a21boi_1
X_2747_ _1816_ _1878_ _1879_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__nand3_2
X_2678_ _1811_ _1812_ _1358_ _1763_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__a211oi_2
X_4417_ _1132_ _1115_ _1117_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__o21ai_1
XANTENNA_input3_A in1[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4348_ _1089_ _1070_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nand2_1
X_4279_ _1011_ _1013_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_30_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4553__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4989__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2867__A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3292__A2 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3975__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3650_ _0169_ _0173_ _0170_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__a21boi_2
Xrebuffer1 _0511_ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_2
X_3581_ net134 net216 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nand2_1
X_2601_ _1433_ _1487_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__nand2_2
X_2532_ net266 net260 net169 net173 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__nand4_2
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4202_ _0929_ _0931_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nand2_1
X_4133_ _0854_ _0818_ _0852_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__and3_1
XFILLER_68_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4064_ _0497_ _0632_ _0780_ _0783_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__nand4_4
X_3015_ _1982_ _1989_ _2146_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_34_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4966_ net88 net180 net83 net176 _1747_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__a41oi_1
XANTENNA__4783__A2 net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4897_ _1638_ _1652_ _1686_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__a21oi_1
X_3917_ _0484_ _0490_ _0486_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a21oi_2
X_3848_ _0562_ _0428_ _0563_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nand3_4
XANTENNA__4535__A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3779_ net245 net239 net103 net99 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand4_4
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_8
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_8
Xfanout143 in1_reg\[5\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
Xfanout132 in1_reg\[7\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_12
Xfanout165 net167 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_2
Xfanout154 net156 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout176 net178 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
Xfanout187 net190 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4223__A1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3734__B1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4820_ _1560_ _1562_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__and2_1
XFILLER_21_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4751_ _1486_ _1488_ _1526_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__a21boi_1
X_4682_ _1449_ _1452_ _1454_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__o21ai_1
X_3702_ _0397_ _0398_ _0237_ _0270_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a31oi_2
X_3633_ _0212_ _0298_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__o21ai_2
X_3564_ _0148_ _0262_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__nand3_2
X_3495_ net252 net104 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand2_1
X_2515_ net271 net24 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__and2_1
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4116_ _0840_ net184 net148 _0839_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nand4_2
XANTENNA_fanout196_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4047_ _0764_ _0765_ _0406_ net70 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout151_X net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4949_ _1741_ _1742_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__nor2_1
XFILLER_20_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3280_ net146 net219 VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__nand2_1
XANTENNA__3046__A net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4803_ _1586_ _1564_ _1562_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__nor3b_2
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4734_ _1497_ _1508_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__nand3b_2
X_2995_ _2101_ _2102_ _2120_ _2125_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__o211ai_4
X_4665_ _1409_ _1412_ _1429_ _1431_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__o22ai_2
X_4596_ _1342_ _1344_ _1357_ _1359_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nand4_1
X_3616_ net264 net87 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout209_A in2_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3547_ _0245_ _0246_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__or2_1
X_3478_ _0174_ _0175_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout199_X net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3165__A1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2780_ _1913_ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__nand2_2
X_4450_ _1039_ _1036_ _1048_ _1044_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o22ai_2
X_4381_ net80 net68 _1122_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__o21ai_1
X_3401_ _0099_ _0097_ _0101_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__o21bai_1
X_3332_ _2439_ _2457_ _2459_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__and3_1
X_3263_ _2281_ _2389_ _2390_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__nand3_2
X_5002_ clknet_3_5__leaf_clk _0018_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfxtp_1
X_3194_ _2312_ _2320_ _2321_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__nand3_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA__2781__C net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout159_A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2978_ net253 net129 VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__nand2_2
X_4717_ _1492_ net181 net112 _1491_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__and4_2
X_4648_ net201 net100 VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
XFILLER_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4579_ _1335_ _1338_ _1341_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__nand3_2
XFILLER_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3414__A net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3950_ _0635_ _0662_ _0633_ _0664_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nand4_4
X_2901_ _2033_ _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__nand2_1
X_3881_ _0416_ _0419_ _0600_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_61_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2832_ _1964_ _1965_ _1966_ _1886_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__a31o_1
X_2763_ _1893_ _1894_ _1891_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__a21o_1
X_4502_ _1061_ _1109_ _1110_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__nand3_1
X_2694_ _1828_ _1829_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__nor2_4
X_4433_ net224 net90 net85 net230 VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__a22oi_1
X_4364_ _1061_ _1062_ _1102_ _1105_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__o2bb2ai_2
X_4295_ net228 net222 net97 net91 VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand4_4
X_3315_ _2341_ _2443_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_69_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3246_ _2373_ _2372_ _2311_ VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__nand3_4
Xrebuffer11 _0345_ VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlymetal6s2s_1
X_3177_ _2184_ _2301_ _2304_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__nand3_1
Xrebuffer44 _2157_ VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_1
Xrebuffer22 _2327_ VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer33 _2220_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_2
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4512__B net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3368__A1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout91_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3100_ net145 net231 VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__nand2_2
X_4080_ _0799_ _0788_ _0798_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nand3_2
X_3031_ _1962_ _2056_ _2058_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__o21ai_2
XANTENNA__5042__Q in1_reg\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4982_ net268 net6 VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and2_1
XFILLER_51_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3933_ _0650_ _0636_ _0649_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__nand3_4
X_3864_ _0571_ _0576_ _0580_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__o21ai_1
X_2815_ _1911_ _1944_ _1945_ _1905_ _1902_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__a32oi_2
XTAP_TAPCELL_ROW_21_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3795_ _0307_ _0309_ _0327_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__o21ai_1
X_2746_ _1878_ _1879_ _1816_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__a21o_1
X_2677_ _1809_ _1810_ _1813_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__a21o_1
X_4416_ _1135_ _1139_ _1138_ _1143_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a2bb2oi_4
X_4347_ _1068_ _1069_ _1087_ _1088_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__nand4_2
X_4278_ _0763_ _1012_ _1009_ _1008_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__o211ai_1
X_3229_ _2353_ _2359_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__nor2_1
XFILLER_22_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2697__B net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4898__B1_N net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3975__C net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4529__B1 _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer2 _0566_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_2
X_3580_ net230 net128 net224 net123 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__nand4_4
X_2600_ _1477_ _1487_ _1433_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__a21o_1
X_2531_ net266 net169 net173 net260 VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a22o_1
XANTENNA__5037__Q in1_reg\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4201_ _0923_ _0927_ _0930_ _0926_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o211ai_2
XANTENNA__4701__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4132_ _0851_ _0853_ _0819_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__o21ai_2
X_4063_ _0497_ _0632_ _0779_ _0781_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__o2bb2ai_4
X_3014_ _1984_ _1985_ _1983_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__a21oi_1
X_4965_ _1757_ _1759_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_34_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3916_ _0548_ _0489_ _0483_ _0487_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a2bb2oi_2
XANTENNA_fanout141_A in1_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4896_ _1683_ _1684_ _1642_ _1649_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__o22ai_1
XFILLER_22_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3847_ _0429_ _0560_ _0561_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nand3_4
X_3778_ net246 net239 net103 VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand3_1
X_2729_ _1841_ _1856_ _1857_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__and3_1
Xfanout111 in1_reg\[11\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_8
Xfanout100 net101 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__buf_2
Xfanout122 net124 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_4
Xfanout155 net156 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_2
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_6
Xfanout144 net146 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_6
Xfanout177 net178 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_2
Xfanout188 net190 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout199 in2_reg\[12\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4223__A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3431__B1 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2501__A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_25_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4750_ _1526_ _1527_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__nand2_1
XANTENNA__4163__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3422__B1 _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4681_ _1450_ _1451_ _1295_ _1334_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__o2bb2ai_2
X_3701_ _0397_ _0398_ _0237_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nand3_4
X_3632_ _0329_ _0311_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nand2_2
X_3563_ _0147_ _0150_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nand2_1
X_3494_ net252 net104 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__and2_1
X_2514_ net271 net17 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4115_ _0692_ _0838_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout189_A net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4046_ _0704_ _0709_ _0761_ _0707_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__o211ai_2
XFILLER_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4948_ net267 _1740_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__nand2_1
XANTENNA__3413__B1 _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4879_ net100 net176 _1666_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a22o_1
XANTENNA__3417__A net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4444__A2 _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2502__Y _0471_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4324__C net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4802_ _1584_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__inv_2
X_2994_ _2012_ _2109_ _2121_ _2122_ _2107_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__a41oi_2
X_4733_ _1505_ _1506_ _1499_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a21o_1
XFILLER_9_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4664_ _1410_ _1413_ _1430_ _1432_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__nand4_2
X_4595_ _1342_ _1357_ _1359_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__nand3_1
X_3615_ net313 net98 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout104_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3546_ _0245_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__nor2_1
X_3477_ _0176_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nand2_2
XANTENNA__4426__A2 net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4029_ _0745_ _0747_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nor2_1
XANTENNA__5007__CLK clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2612__A2_N net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3165__A2 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3928__A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4160__B net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4380_ _1122_ _1124_ _1119_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a21o_1
X_3400_ _0098_ _0101_ _0100_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nand3_1
XANTENNA__5045__Q in1_reg\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3331_ _2457_ _2459_ _2439_ VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__a21o_1
X_3262_ _2280_ _2387_ _2388_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__nand3_1
XFILLER_38_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3193_ _2312_ _2320_ _2321_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__and3_1
X_5001_ clknet_3_5__leaf_clk _0017_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfxtp_1
XFILLER_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2977_ _2009_ _2015_ _2011_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__a21oi_2
X_4716_ net100 net193 net187 net106 VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_12_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4647_ _1209_ _1309_ _1305_ _1307_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__o22a_1
XFILLER_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4578_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__inv_2
X_3529_ _0224_ _0225_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_55_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4526__A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2900_ _2028_ _2029_ _1993_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__nand3_2
X_3880_ net318 _0594_ _0596_ _0265_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_61_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2831_ _1881_ _1961_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__nand2_1
XFILLER_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2762_ _0395_ net75 _1893_ _1894_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__o211ai_1
X_4501_ _1062_ _1103_ _1106_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__nand3_1
X_2693_ _1823_ _1824_ _1826_ _1776_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__o211a_1
X_4432_ net216 net96 VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__nand2_1
X_4363_ _1096_ _1098_ _1100_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a21o_1
X_4294_ net223 net91 VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nand2_2
X_3314_ net259 net104 net98 net264 VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_69_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3245_ _2374_ _2310_ _2375_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__nand3_4
X_3176_ _2184_ _2301_ _2304_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__and3_1
Xrebuffer12 net147 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_4
Xrebuffer45 in2_reg\[9\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_24_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout224_X net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3368__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4512__C net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_5__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4868__A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout84_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2510__Y _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3030_ _2161_ _2158_ _2160_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__o21ai_2
XFILLER_36_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3047__A1 _0395_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4981_ net269 net5 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and2_1
X_3932_ _0646_ _0641_ _0637_ _0648_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__o211ai_4
XFILLER_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__3389__A1_N _2476_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3863_ _0569_ _0572_ _0574_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and3_1
X_2814_ _1947_ _1948_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__nand2_1
XFILLER_31_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3794_ _0311_ _0328_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nand2_2
X_2745_ _1878_ _1879_ _1816_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__a21oi_1
X_2676_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__inv_2
X_4415_ _1153_ _1163_ _1165_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__o21a_1
X_4346_ _1070_ _1087_ _1088_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__nand3_1
X_4277_ _1008_ _1013_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nand2_1
XANTENNA__3286__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3228_ net78 net77 _2356_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__o21ai_2
X_3159_ net154 net213 net208 net160 VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_37_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4538__A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3155__A net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__3816__A3 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2505__Y _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3975__D net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer3 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_2
X_2530_ net271 net173 net265 VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__and3_1
XFILLER_5_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4200_ _0643_ _0791_ _0794_ _0790_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a22oi_4
X_4131_ _0852_ _0854_ _0818_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a21oi_1
X_4062_ _0776_ _0778_ net79 _0548_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__a211o_1
X_3013_ net166 net207 _2043_ _2145_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__a31o_1
X_4964_ net267 _1755_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5040__CLK clknet_3_4__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3915_ _0502_ net301 _0629_ _0631_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_51_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4895_ _1681_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__nand2_1
X_3846_ _0554_ _0558_ _0561_ _0429_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__o211a_1
XANTENNA_fanout134_A in1_reg\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3777_ net240 net98 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nand2_1
X_2728_ _1798_ _1831_ _1860_ _1861_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__o211ai_1
X_2659_ _1792_ _1782_ _1791_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__nand3_4
Xfanout101 net105 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_6
Xfanout112 in1_reg\[10\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_4
X_4329_ _0950_ _0954_ _0952_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__a21oi_1
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_6
Xfanout134 in1_reg\[7\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_4
Xfanout156 in1_reg\[3\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_2
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_6
Xfanout178 in2_reg\[15\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
Xfanout167 in1_reg\[1\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
XFILLER_42_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4759__A1 _0460_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3967__C1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3700_ _0397_ _0237_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nand2_1
XANTENNA__3422__B2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4680_ _1337_ _1450_ _1451_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__nand3_1
X_3631_ _0312_ _0327_ _0328_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__and3_1
X_3562_ net159 net165 net197 net192 _0121_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__a41o_1
X_2513_ net274 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__inv_2
X_3493_ _2442_ _2447_ _2444_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a21oi_2
X_4114_ net142 net138 net196 net188 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nand4_2
XFILLER_56_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4045_ _0694_ _0697_ _0705_ _0762_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__o211ai_2
XFILLER_49_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4947_ _1719_ _1726_ _1739_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a21oi_1
X_4878_ _1607_ _1608_ _1611_ _1616_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__o211ai_4
X_3829_ net288 _0511_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__nand2_2
XANTENNA__3417__B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_27_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2512__A net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4801_ _1582_ _1583_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__and2_1
X_2993_ _2120_ _2125_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4324__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4732_ _1505_ _1506_ _1499_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__a21oi_2
X_4663_ _1434_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__inv_2
X_3614_ _0196_ _0201_ _0198_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__a21oi_4
X_4594_ _1345_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__nand2_1
X_3545_ _2481_ _0078_ _0084_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__and3_1
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3476_ _0171_ _0173_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__nand2_1
XFILLER_69_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4028_ _0571_ _0577_ _0744_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_67_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input27_A in2[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4990__Q in2_reg\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3928__A2 _0493_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2513__Y _0592_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4441__B _1191_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4160__C _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3330_ _2457_ _2459_ _2439_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__a21oi_1
X_5000_ clknet_3_5__leaf_clk _0016_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfxtp_1
X_3261_ _2389_ _2390_ _2281_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__a21oi_1
X_3192_ _2320_ _2321_ _2312_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__a21o_1
XANTENNA__3801__A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2976_ net263 net258 net130 net122 _2008_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__a41o_1
X_4715_ net106 net100 net193 net187 VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout214_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4646_ _1212_ _1306_ _1305_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a21oi_2
X_4577_ _1339_ _1340_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand2_2
XFILLER_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3528_ _2426_ _2470_ _2466_ _2468_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o2bb2ai_2
X_3459_ net133 net224 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_55_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4526__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3430__B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3158__A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2508__Y _0537_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2830_ _1961_ _1815_ _1883_ _1962_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__nand4_4
XFILLER_43_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2761_ _1893_ _1894_ net175 net220 VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__nand4_1
X_2692_ _1776_ _1826_ _1825_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__a21oi_4
X_4500_ _1254_ _1255_ _1200_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nand3_1
XFILLER_61_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4431_ _1029_ _1035_ _1032_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__a21boi_2
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4362_ _0962_ _0978_ _1096_ _1098_ _0964_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__o2111ai_1
XANTENNA__2888__A2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4293_ net224 net90 VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__and2_1
X_3313_ net264 net99 VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_69_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3244_ _2332_ _2371_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__nand2_1
X_3175_ _2301_ _2304_ _2184_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__a21o_1
Xrebuffer24 _0499_ VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_6
Xrebuffer13 _0673_ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_1
XFILLER_54_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2959_ _2088_ _2090_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__nor2_1
X_4629_ _1327_ _1396_ _1394_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__and3_1
XFILLER_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout77_A _0471_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput60 net60 VGND VGND VPWR VPWR out[4] sky130_fd_sc_hd__buf_2
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3351__A net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4980_ net268 net4 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and2_1
XANTENNA__3047__A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3931_ _0637_ _0648_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__nand2_2
X_3862_ _0569_ _0572_ _0373_ net70 VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__o2bb2a_1
X_2813_ _1911_ _1944_ _1945_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__nand3_2
X_3793_ _0503_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
X_2744_ _1878_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nand2_1
X_2675_ _1162_ _1756_ _1735_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__o21a_1
X_4414_ _1163_ _1153_ net273 VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a21oi_1
X_4345_ _1087_ _1088_ _1070_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21o_1
X_4276_ _1008_ _1009_ _1013_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21o_1
XANTENNA__3286__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3227_ _2353_ _2356_ net236 net135 VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__and4b_1
X_3158_ net154 net213 VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__nand2_2
XFILLER_36_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4235__A1 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3089_ _2199_ _2208_ _2219_ _2207_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__o211ai_1
XANTENNA_fanout167_X net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4538__A2 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4171__B1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3155__B net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4474__A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2515__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer4 _0345_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_6
X_4130_ _0850_ _0844_ _0819_ _0854_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__o211a_1
X_4061_ _0775_ _0777_ net235 net97 VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__o211a_1
X_3012_ net166 net214 net207 net170 VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__a22oi_2
X_4963_ _1751_ _1753_ _1749_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_34_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3914_ net301 _0502_ _0629_ _0631_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__o2bb2a_1
X_4894_ _1679_ _1680_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__nand2_1
XFILLER_32_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3845_ _0546_ _0556_ net281 _0478_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__o211ai_2
X_3776_ _0305_ _0485_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout127_A in1_reg\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2727_ _1798_ _1831_ _1860_ _1861_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__o211a_1
XANTENNA__2951__A1 _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2658_ _1788_ _1790_ _1784_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__a21o_1
Xfanout113 in1_reg\[10\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_2
Xfanout102 net105 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_4
X_2589_ net271 _1380_ _1390_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__and3_1
Xfanout124 in1_reg\[9\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_6
X_4328_ _0950_ _0954_ _0952_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__a21o_1
Xfanout135 net136 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_6
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input1_A in1[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout168 in1_reg\[1\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout179 in2_reg\[15\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_2
X_4259_ _0816_ _0902_ _0992_ _0993_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__a22oi_1
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_4
XFILLER_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4759__A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3719__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4993__Q in2_reg\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_7__f_clk_X clknet_3_7__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3630_ _0307_ _0309_ _0328_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__o21ai_2
X_3561_ net170 net177 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__nand2_1
XANTENNA__3347__Y net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2512_ net178 VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__inv_2
X_3492_ _2445_ _2452_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__nand2_1
X_4113_ net138 net196 VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nand2_1
X_4044_ _0694_ _0697_ _0705_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__o211a_1
XANTENNA__4635__A _1034_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4946_ _1719_ _1726_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__nand3_1
X_4877_ _1615_ _1665_ _1613_ _1614_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__nand4_2
X_3828_ _0538_ _0510_ net288 VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__o21ai_1
X_3759_ _0440_ _0441_ _0461_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__o21ai_1
XANTENNA__2688__B1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4429__A1 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4062__C1 _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4904__A2 _1157_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4117__B1 _0417_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4800_ _1579_ _1581_ _1566_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__a21o_1
XFILLER_61_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2992_ _2014_ _2108_ _2115_ _2117_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_16_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4731_ _1506_ _1499_ _1505_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__nand3_1
X_4662_ _1414_ _1431_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__nor2_1
X_3613_ _0199_ _0206_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__nand2_1
XANTENNA__3159__B2 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3159__A1 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4593_ _1357_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__nand2_1
X_3544_ _0078_ _0084_ _2481_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a21oi_2
XANTENNA__4108__B1 _0471_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3475_ _2410_ _2412_ _2415_ _0169_ _0170_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o2111ai_4
XFILLER_69_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout194_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4027_ _0741_ _0742_ _0612_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a21oi_2
XFILLER_37_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4929_ _1699_ _1718_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__nor2_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3165__A4 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3625__A2 _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2523__A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3260_ _2387_ _2388_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__nand2_1
X_3191_ _2320_ _2321_ _2312_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4714_ net106 net100 net193 net187 VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__and4_1
X_2975_ _1928_ _2010_ _2009_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__a21oi_2
X_4645_ _0515_ net71 _1212_ _1306_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__o22a_1
X_4576_ _1059_ _1193_ _1253_ _1257_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__o22ai_2
XANTENNA_fanout207_A net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3527_ _0222_ _0178_ _0221_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_55_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3458_ net140 net219 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout197_X net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3389_ _2476_ _2477_ _0085_ _0086_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4526__C net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4823__A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4740__B1 _1034_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2760_ net175 net220 _1893_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__a22o_1
X_2691_ _1585_ _1774_ _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__o21a_1
X_4430_ _1179_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__nand2_1
X_4361_ _1061_ _1062_ _1103_ _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand4_4
XANTENNA__3084__A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4292_ _0917_ _1030_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__nand2_4
X_3312_ net256 net108 VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__nand2_2
X_3243_ net299 _2328_ _2369_ _2370_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__nand4_4
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3174_ _2301_ _2304_ _2184_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__a21oi_2
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer25 _2272_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_2
Xrebuffer14 _0541_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_6
Xrebuffer36 net252 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_6
XFILLER_54_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2958_ _2085_ _2086_ _2087_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__nand3_2
X_4628_ _1297_ _1300_ _1323_ _1395_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__o211ai_2
X_2889_ _2016_ _2008_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__nand2_1
X_4559_ _1320_ _1301_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__nand2_1
XFILLER_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput50 net50 VGND VGND VPWR VPWR out[24] sky130_fd_sc_hd__buf_2
Xoutput61 net61 VGND VGND VPWR VPWR out[5] sky130_fd_sc_hd__buf_2
XFILLER_0_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3351__B net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3930_ _0645_ _0638_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2_1
X_3861_ _0573_ _0574_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__nand2_1
X_3792_ _0501_ _0494_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__nand2_2
X_2812_ _1910_ _1942_ _1943_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nand3_1
X_2743_ _1769_ _1875_ _1877_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__nand3_2
X_2674_ _1809_ _1810_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nand2_1
X_4413_ _1163_ _1153_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__nand2_1
X_4344_ _1087_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__nand2_1
X_4275_ _0763_ _1012_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nor2_1
X_3226_ net78 net77 _2353_ _2355_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__o22a_1
XANTENNA_fanout274_A net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3157_ net165 net202 VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__nand2_1
XFILLER_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3088_ _2208_ _2199_ _2219_ _2207_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__o211a_4
XFILLER_54_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2605__B net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2797__A2 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4171__B2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4548__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4474__A2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4714__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer5 _0335_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3362__A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4060_ net235 in1_reg\[13\] _0775_ _0777_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__a211o_1
X_3011_ net166 net208 _2043_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__and3_1
X_4962_ _1754_ _1750_ _1749_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4893_ _1604_ _1632_ _1634_ _1679_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__o211a_1
X_3913_ net301 _0630_ _0502_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_34_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3844_ _0479_ _0557_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nand2_2
X_3775_ net239 net103 net99 net245 VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a22oi_1
X_2726_ _1841_ _1858_ _1798_ _1831_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__o2bb2ai_4
XANTENNA__2951__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2657_ _1788_ _1790_ _1784_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__a21oi_2
Xfanout103 net105 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_4
X_2588_ _1097_ _1369_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__nand2_1
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_4
X_4327_ _1068_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__nand2_1
Xfanout114 net117 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_4
Xfanout147 in1_reg\[5\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_6
Xfanout136 in1_reg\[7\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_6
X_4258_ _0816_ _0902_ _0992_ _0993_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__nand4_2
Xfanout169 in1_reg\[1\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
Xfanout158 in1_reg\[3\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlymetal6s2s_1
X_3209_ _2196_ _2338_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__nand2_2
X_4189_ net228 net222 net102 net97 VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__nand4_4
XFILLER_15_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2526__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3357__A _0362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _0238_ _0241_ _0247_ _0240_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a2bb2oi_2
X_2511_ net86 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__inv_2
X_3491_ _0191_ _0190_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__nor2_8
X_4112_ _0832_ _0833_ _0821_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand3_4
X_4043_ _0700_ _0702_ _0703_ _0708_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4635__B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4945_ _1737_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__nand2b_1
XFILLER_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4876_ _1607_ _1608_ _1611_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout237_A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3827_ _0541_ _0538_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3758_ _0442_ _0458_ _0459_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand3_1
X_2709_ net253 net147 VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__nand2_1
X_3689_ _0378_ _0349_ _0377_ _0386_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a31o_1
XANTENNA__2688__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__3730__A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4062__B1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2915__A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4117__B2 _0559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2991_ _2014_ _2108_ _2115_ _2117_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__o22a_1
XFILLER_61_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4471__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4730_ _1506_ _1499_ _1505_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__and3_1
XFILLER_9_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4661_ _1417_ _1425_ _1426_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__nand3_1
X_3612_ _0308_ _0310_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nand2_1
X_4592_ _1350_ _1352_ net131 net179 VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__nand4_1
X_3543_ _2478_ _0083_ _0079_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__a21oi_1
XANTENNA__4108__B2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3474_ _0169_ _0170_ _0173_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__nand3_1
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout187_A net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4026_ _0737_ _0740_ _0612_ _0742_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_67_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4928_ _1699_ _1718_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout142_X net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4859_ _1544_ _1600_ _1599_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__a21boi_4
XFILLER_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA__3460__A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3086__A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4035__B1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4999__Q in2_reg\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3190_ _2232_ _2316_ net150 net219 _2315_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_29_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2974_ _2104_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__nand2_2
X_4713_ _1486_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__nand2_1
X_4644_ _1410_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__nand2_1
XFILLER_30_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4575_ _1059_ _1193_ _1254_ _1256_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__a2bb2oi_2
XANTENNA_fanout102_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3526_ _0181_ _0218_ _0219_ _0179_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a31oi_4
XFILLER_39_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3457_ _2429_ _2433_ _2431_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a21oi_2
X_3388_ _2476_ _2477_ _0088_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a21o_1
XFILLER_57_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4526__D net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4009_ _0430_ _0472_ _0469_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2608__B net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5020__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input32_A in2[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2534__A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2690_ _1585_ _1774_ _0373_ net79 VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a211o_1
X_4360_ _1096_ _1098_ _1101_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nand3_1
X_3311_ _2337_ _2343_ _2339_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__a21o_1
XANTENNA__2700__C net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4291_ net228 net91 VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__nand2_1
X_3242_ _2371_ _2331_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__nand2_1
X_3173_ _2284_ _2303_ _2302_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__nand3_2
Xrebuffer15 _0713_ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_1
Xrebuffer26 _0670_ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA__5043__CLK clknet_3_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3222__B2 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3222__A1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2957_ _2085_ _2086_ _2087_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__and3_1
X_2888_ net81 net77 _1926_ _2013_ _2012_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__o221ai_4
X_4627_ _1323_ _1329_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand2_1
X_4558_ _1299_ _1300_ _1319_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o21ai_1
XFILLER_1_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout105_X net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4489_ _1242_ _1239_ _1202_ _1244_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__o211ai_2
X_3509_ _0194_ _0204_ _0205_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__and3_1
XANTENNA__3289__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4537__C net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput51 net51 VGND VGND VPWR VPWR out[25] sky130_fd_sc_hd__buf_2
Xoutput40 net40 VGND VGND VPWR VPWR out[15] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR out[6] sky130_fd_sc_hd__buf_2
XANTENNA__2529__A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3351__C net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3860_ _0573_ net177 net165 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__and3_1
X_2811_ _1857_ _1909_ _1944_ _1945_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__a22oi_2
X_3791_ _0491_ _0492_ _0499_ _0500_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o211ai_4
XANTENNA__3079__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2742_ _1875_ _1877_ _1769_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__a21o_1
X_4412_ _1157_ _1161_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nand2_2
X_2673_ _1767_ _1769_ _1805_ _1808_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__a22o_1
X_4343_ _1082_ _1071_ _1081_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__nand3_4
X_4274_ net153 net178 _0765_ _0763_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__a31o_1
X_3225_ net248 net242 net129 net121 VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__nand4_2
XFILLER_39_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3156_ _2174_ _2178_ _2175_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__a21oi_1
XFILLER_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3087_ _2217_ _2218_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout267_A net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3989_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__inv_2
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3436__C net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4548__B net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4714__D net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2945__B1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer6 _0335_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3010_ _2141_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__nand2_1
X_4961_ _1747_ _1748_ _1750_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__o211ai_1
X_4892_ _1681_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__inv_2
X_3912_ _0620_ _0626_ _0617_ _0625_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__o211ai_4
XFILLER_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3843_ _0557_ _0478_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand2_2
X_3774_ net245 net98 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__nand2_2
X_2725_ _1839_ _1840_ _1858_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__o21ai_1
X_2656_ _1785_ _1786_ _1784_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__o21ai_2
XANTENNA__4649__A net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout104 net105 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_6
X_2587_ _0880_ _1086_ _1369_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__a21o_1
X_4326_ _1065_ _1067_ _1063_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a21o_1
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_4
Xfanout126 in1_reg\[8\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_4
Xfanout115 net117 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_6
X_4257_ _0992_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand2_1
Xfanout148 in1_reg\[4\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
Xfanout159 net161 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_6
X_4188_ net228 net222 net102 net97 VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__and4_1
X_3208_ net259 net108 net104 net264 VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__a22oi_1
X_3139_ _2265_ _2266_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__nand3_2
XFILLER_15_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3728__A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__3463__A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout85_X net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3104__B1 _0406_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2630__A2 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3357__B net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3490_ _2430_ _0188_ _0182_ _0187_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__o211a_4
X_2510_ net184 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__clkinv_4
XFILLER_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4111_ _0830_ _0826_ _0822_ _0831_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__o211ai_4
X_4042_ _0691_ _0696_ _0692_ _0434_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_49_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4635__C net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4944_ _1712_ _1716_ _1736_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__or3_1
X_4875_ _0537_ net68 VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__nor2_1
XFILLER_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_A in1_reg\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3826_ _0506_ _0509_ _0532_ _0533_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a22oi_2
X_3757_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__inv_2
X_2708_ net253 net147 VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__and2_1
X_3688_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__inv_2
X_2639_ net162 net157 net250 net243 VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__nand4_4
XANTENNA__2688__A2 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4309_ _1038_ _0905_ _1037_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a31oi_4
XANTENNA__3433__D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3730__B net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__3876__A1 net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2990_ _2008_ _2014_ _2121_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_16_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4471__B net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4660_ _1307_ _1415_ _1427_ _1428_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a2bb2oi_2
X_3611_ _0307_ _0309_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nor2_2
X_4591_ _1350_ _1352_ net77 net69 VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__o2bb2ai_1
X_3542_ _0238_ _0241_ _0240_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o21ai_1
XANTENNA__3815__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3473_ _0169_ _0170_ _0172_ _2412_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_56_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4025_ _0737_ _0740_ _0612_ _0742_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__o211a_1
XFILLER_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4927_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__inv_2
XFILLER_52_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4858_ _1554_ _1157_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_50_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3809_ _0518_ _0519_ _0513_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
X_4789_ net106 net180 _1567_ _1569_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a22o_1
XFILLER_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3086__A2 _0449_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__3849__A1 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__3651__A net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2973_ net80 net78 _2098_ _2100_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__o211ai_1
X_4712_ _1483_ _1485_ net118 net178 VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__nand4b_2
XANTENNA__3098__A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4643_ _1408_ net181 net118 _1407_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__nand4b_4
X_4574_ _1335_ _1338_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__nand2_1
X_3525_ net320 _0222_ _0178_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__a21oi_4
X_3456_ _2429_ _2433_ _2431_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__a21o_1
XANTENNA__3561__A net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3387_ _0085_ _0086_ _2476_ _2477_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__o211ai_1
XANTENNA__3280__B net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4008_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__inv_2
XFILLER_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input25_A in2[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3310_ _2196_ _2338_ _2337_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__a21oi_4
XANTENNA__2700__D net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4290_ net217 net102 VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nand2_1
X_3241_ _2329_ _2330_ _2369_ _2370_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__nand4_1
X_3172_ _2297_ _2298_ _2286_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__a21o_1
XFILLER_39_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer16 _0675_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_6
XFILLER_54_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer27 _2241_ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__buf_1
XFILLER_66_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2956_ _2085_ _2086_ _2087_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__a21o_1
X_2887_ _2017_ _2011_ _2007_ _2019_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__o211ai_4
X_4626_ _1324_ _1326_ _1192_ _1329_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout212_A in2_reg\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4557_ _1318_ _1319_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__nand2_1
X_4488_ _1242_ _1239_ _1202_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__o211a_1
X_3508_ _0194_ _0205_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nand2_2
X_3439_ _0135_ _0136_ _0129_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__and3_2
XANTENNA__3289__A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4537__D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4238__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__3213__A2 _0504_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput52 net52 VGND VGND VPWR VPWR out[26] sky130_fd_sc_hd__buf_2
Xoutput41 net41 VGND VGND VPWR VPWR out[16] sky130_fd_sc_hd__buf_2
Xoutput63 net63 VGND VGND VPWR VPWR out[7] sky130_fd_sc_hd__buf_2
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__3351__D net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3790_ _0491_ _0492_ _0500_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__o21ai_4
X_2810_ _1931_ _1938_ _1937_ _1920_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__o211ai_4
X_2741_ _1871_ _1872_ _1821_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__nand3_1
XANTENNA__3807__C net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4411_ _0882_ _1023_ net295 _0886_ _1025_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__o221a_4
X_2672_ _1806_ _1801_ _1769_ _1767_ _1805_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__o2111ai_4
X_4342_ _1072_ _1083_ _1084_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nand3_2
X_4273_ _0765_ net178 net153 VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__and3_1
XANTENNA__4638__C net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3224_ net248 net241 net129 net121 VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__and4_1
.ends
