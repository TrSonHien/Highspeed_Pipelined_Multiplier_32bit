* NGSPICE file created from pipelined_mult.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for mult_16x16 abstract view
.subckt mult_16x16 VGND VPWR clk in1[0] in1[10] in1[11] in1[12] in1[13] in1[14] in1[15]
+ in1[1] in1[2] in1[3] in1[4] in1[5] in1[6] in1[7] in1[8] in1[9] in2[0] in2[10] in2[11]
+ in2[12] in2[13] in2[14] in2[15] in2[1] in2[2] in2[3] in2[4] in2[5] in2[6] in2[7]
+ in2[8] in2[9] out[0] out[10] out[11] out[12] out[13] out[14] out[15] out[16] out[17]
+ out[18] out[19] out[1] out[20] out[21] out[22] out[23] out[24] out[25] out[26] out[27]
+ out[28] out[29] out[2] out[30] out[31] out[3] out[4] out[5] out[6] out[7] out[8]
+ out[9] rst
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_16 abstract view
.subckt sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for add3x64 abstract view
.subckt add3x64 VGND VPWR clk in1[0] in1[10] in1[11] in1[12] in1[13] in1[14] in1[15]
+ in1[16] in1[17] in1[18] in1[19] in1[1] in1[20] in1[21] in1[22] in1[23] in1[24] in1[25]
+ in1[26] in1[27] in1[28] in1[29] in1[2] in1[30] in1[31] in1[32] in1[33] in1[34] in1[35]
+ in1[36] in1[37] in1[38] in1[39] in1[3] in1[40] in1[41] in1[42] in1[43] in1[44] in1[45]
+ in1[46] in1[47] in1[48] in1[49] in1[4] in1[50] in1[51] in1[52] in1[53] in1[54] in1[55]
+ in1[56] in1[57] in1[58] in1[59] in1[5] in1[60] in1[61] in1[62] in1[63] in1[6] in1[7]
+ in1[8] in1[9] in2[0] in2[10] in2[11] in2[12] in2[13] in2[14] in2[15] in2[16] in2[17]
+ in2[18] in2[19] in2[1] in2[20] in2[21] in2[22] in2[23] in2[24] in2[25] in2[26] in2[27]
+ in2[28] in2[29] in2[2] in2[30] in2[31] in2[32] in2[33] in2[34] in2[35] in2[36] in2[37]
+ in2[38] in2[39] in2[3] in2[40] in2[41] in2[42] in2[43] in2[44] in2[45] in2[46] in2[47]
+ in2[48] in2[49] in2[4] in2[50] in2[51] in2[52] in2[53] in2[54] in2[55] in2[56] in2[57]
+ in2[58] in2[59] in2[5] in2[60] in2[61] in2[62] in2[63] in2[6] in2[7] in2[8] in2[9]
+ in3[0] in3[10] in3[11] in3[12] in3[13] in3[14] in3[15] in3[16] in3[17] in3[18] in3[19]
+ in3[1] in3[20] in3[21] in3[22] in3[23] in3[24] in3[25] in3[26] in3[27] in3[28] in3[29]
+ in3[2] in3[30] in3[31] in3[32] in3[33] in3[34] in3[35] in3[36] in3[37] in3[38] in3[39]
+ in3[3] in3[40] in3[41] in3[42] in3[43] in3[44] in3[45] in3[46] in3[47] in3[48] in3[49]
+ in3[4] in3[50] in3[51] in3[52] in3[53] in3[54] in3[55] in3[56] in3[57] in3[58] in3[59]
+ in3[5] in3[60] in3[61] in3[62] in3[63] in3[6] in3[7] in3[8] in3[9] out[0] out[10]
+ out[11] out[12] out[13] out[14] out[15] out[16] out[17] out[18] out[19] out[1] out[20]
+ out[21] out[22] out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[2] out[30]
+ out[31] out[32] out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[3] out[40]
+ out[41] out[42] out[43] out[44] out[45] out[46] out[47] out[48] out[49] out[4] out[50]
+ out[51] out[52] out[53] out[54] out[55] out[56] out[57] out[58] out[59] out[5] out[60]
+ out[61] out[62] out[63] out[6] out[7] out[8] out[9] rst
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

.subckt pipelined_mult VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[16] a[17]
+ a[18] a[19] a[1] a[20] a[21] a[22] a[23] a[24] a[25] a[26] a[27] a[28] a[29] a[2]
+ a[30] a[31] a[3] a[4] a[5] a[6] a[7] a[8] a[9] b[0] b[10] b[11] b[12] b[13] b[14]
+ b[15] b[16] b[17] b[18] b[19] b[1] b[20] b[21] b[22] b[23] b[24] b[25] b[26] b[27]
+ b[28] b[29] b[2] b[30] b[31] b[3] b[4] b[5] b[6] b[7] b[8] b[9] clk p[0] p[10] p[11]
+ p[12] p[13] p[14] p[15] p[16] p[17] p[18] p[19] p[1] p[20] p[21] p[22] p[23] p[24]
+ p[25] p[26] p[27] p[28] p[29] p[2] p[30] p[31] p[32] p[33] p[34] p[35] p[36] p[37]
+ p[38] p[39] p[3] p[40] p[41] p[42] p[43] p[44] p[45] p[46] p[47] p[48] p[49] p[4]
+ p[50] p[51] p[52] p[53] p[54] p[55] p[56] p[57] p[58] p[59] p[5] p[60] p[61] p[62]
+ p[63] p[6] p[7] p[8] p[9] rst
XFILLER_214_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_in2[0] net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_213_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_4_3351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_1_Left_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_194_3_4191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_161_4_Right_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_250 VGND VGND VPWR VPWR i_add_250/HI net250 sky130_fd_sc_hd__conb_1
XFILLER_172_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_261 VGND VGND VPWR VPWR i_add_261/HI net261 sky130_fd_sc_hd__conb_1
Xi_add_272 VGND VGND VPWR VPWR i_add_272/HI net272 sky130_fd_sc_hd__conb_1
XANTENNA__1042__Q term_high\[63\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_218_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0613__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_209_3_4343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_3_Right_1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_194_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_3_3734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_207_3_Right_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_1_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_163_1_Left_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_4_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0985_ clknet_4_9_0_clk_regs _0006_ VGND VGND VPWR VPWR p_ll_pipe\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_158_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_2_Left_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_221_2917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_3_3310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_i_add_out[22] net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_131_3_Right_1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1127__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_4_Left_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_3_Left_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_178_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0608__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_2_Right_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0770_ _0280_ _0284_ _0285_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__o21a_1
XFILLER_196_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0630__X _0088_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_170_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_196_3_4210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire178_A net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_208_3_Right_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_229_3186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3_4018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_225_3028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire133_X net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_201_3_4261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_145_4_Left_959 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_3_3234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_209_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_4_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0968_ net186 net166 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__and2_1
XFILLER_118_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0899_ _0398_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nor2_1
XFILLER_118_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_4_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_111_2_Left_925 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_delaybuf_0_clk_A delaynet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3_3933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_4_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_191_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input55_A b[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_169_2_Right_1457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_207_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_X net10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_2_Right_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0822_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_2
XFILLER_200_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0753_ _0267_ _0268_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nor2_1
XFILLER_143_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0684_ p_hl\[0\] net155 p_hl\[1\] net147 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a22oi_4
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_regs_X clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_209_3_Right_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_out[4] p_ll\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1167_ clknet_4_5_0_clk_regs _0188_ VGND VGND VPWR VPWR p_hh_pipe\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1098_ clknet_4_11_0_clk_regs _0119_ VGND VGND VPWR VPWR term_low\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_187_3_4122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3_3987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[9] net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_1_Left_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_176_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_4_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_60_2_Right_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_1_Right_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_192_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_204_1_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_204_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_1_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire133 _0153_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_1
Xwire144 p_lh\[4\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_4
Xwire155 p_lh\[0\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_8
Xwire166 p_hh\[21\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_4
XFILLER_8_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire177 net115 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_4
XANTENNA__1139__D net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0621__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_171_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input58_X net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2_3587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1021_ clknet_4_6_0_clk_regs _0042_ VGND VGND VPWR VPWR term_high\[42\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_33_2_Left_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_99_2_Right_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_139_3_3765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_208_3_4328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0805_ _0249_ _0314_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nand2_1
XFILLER_176_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0736_ p_hl\[9\] net139 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__nand2b_1
XFILLER_116_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_3_Right_1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0667_ net186 net314 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__and2_1
XFILLER_48_1372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0598_ net186 net301 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and2_1
XFILLER_26_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_4_Left_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_3_Left_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_3_Left_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_4_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_61_2_Right_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_178_3_4034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold30 mid_sum\[9\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_62_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold41 mid_sum\[20\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold52 p_hh_pipe\[26\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 p_ll_pipe\[21\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 p_ll_pipe\[11\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold85 p_hh_pipe\[2\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_217_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A a[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0616__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_3_3695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_3_3204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_153_2_Right_1441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hh_in2[14] net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output86_A net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_1315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_154_4_Left_968 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_4_Left_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1004_ clknet_4_3_0_clk_regs _0025_ VGND VGND VPWR VPWR p_ll_pipe\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_643 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_212_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_4_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_4_3846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0813__X _0145_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_184_3_4088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_1303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1160__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_120_2_Left_934 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0719_ _0237_ _0238_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nand2_1
XFILLER_104_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hh_in2[0] net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_191_2_4156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_4_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_965 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_4_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput75 net75 VGND VGND VPWR VPWR p[18] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_62_2_Right_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput97 net97 VGND VGND VPWR VPWR p[38] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR p[28] sky130_fd_sc_hd__buf_2
XFILLER_7_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_1_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[13] net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output124_A net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1033__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0991__D _0012_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_2_3627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_1677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_141_4_3776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0671__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_140_2_Left_1155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_202_1_Left_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_968 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_147_3_3805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire163_X net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_228_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_135_1_Left_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_223_2981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_223_2970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_1_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_1340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_3_Right_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_643 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_4_3346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_2_3592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1056__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_1_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_194_3_4192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_182_3_Right_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_240 VGND VGND VPWR VPWR i_add_240/HI net240 sky130_fd_sc_hd__conb_1
Xi_add_251 VGND VGND VPWR VPWR i_add_251/HI net251 sky130_fd_sc_hd__conb_1
XFILLER_100_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xi_add_262 VGND VGND VPWR VPWR i_add_262/HI net262 sky130_fd_sc_hd__conb_1
Xi_add_273 VGND VGND VPWR VPWR i_add_273/HI net273 sky130_fd_sc_hd__conb_1
XFILLER_199_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_2_3557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_186_3_4107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_140_2_Right_1428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_3_4344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_3_4350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_2_Left_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_3_Left_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_4_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_133_3_3735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_2_Right_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input40_X net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_3092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0628__X _0086_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_1173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0984_ clknet_4_14_0_clk_regs _0005_ VGND VGND VPWR VPWR p_ll_pipe\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_158_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_50_1_Right_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_141_2_Left_1156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1057__D _0078_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_4_3276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1079__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1143__Q p_hh_pipe\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_221_2918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_86_3_Left_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0883__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[21] net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_110_1_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_180_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_971 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_160_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_183_3_Right_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_163_4_Left_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_156_4_3851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0624__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_169_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_161_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_219_Left_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_196_3_4211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_rst net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_129_4_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3_4019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_2_Right_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_201_3_4262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_3_3235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_228_Left_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_179_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0967_ net186 net167 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__and2_1
XFILLER_118_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_142_2_Left_1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_1_Right_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0898_ p_hl\[27\] p_lh\[27\] VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__and2_1
XFILLER_118_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[19] p_ll\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_2_3632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_4_3781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3_3934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_148_3_3810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input48_A b[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0619__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_184_3_Right_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_194_1_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_211_1_Left_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0821_ p_hl\[18\] p_lh\[18\] VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__and2_1
XANTENNA__0641__X _0099_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0752_ p_hl\[11\] net153 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_138_1_Right_1244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_144_1_Left_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0683_ _0205_ _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o21ai_1
XFILLER_143_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_1_Left_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_170_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[3] p_ll\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_2_Right_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_4_3316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1166_ clknet_4_5_0_clk_regs _0187_ VGND VGND VPWR VPWR p_hh_pipe\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_2_3562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1097_ clknet_4_9_0_clk_regs _0118_ VGND VGND VPWR VPWR term_low\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_206_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_3_4123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3_3988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[8] net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_93_3_Right_1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_1_Right_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0711__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_2_Left_1158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3_3740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_rst net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_2_Right_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_190_2_Right_1478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire145 p_lh\[3\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_4
Xwire134 _0322_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_2
XFILLER_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire156 p_hh\[31\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_4
XFILLER_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire178 net114 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_4
Xwire167 p_hh\[20\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_4
XFILLER_166_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_4_3281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_173_3_Left_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_2_3588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0994__D _0015_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1020_ clknet_4_6_0_clk_regs _0041_ VGND VGND VPWR VPWR term_high\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_193_3_4177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_185_3_Right_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_201_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_222_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_3_Right_1132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_1_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_15_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0804_ _0244_ _0247_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a21oi_2
XFILLER_163_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_208_3_4329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0735_ p_hl\[9\] net139 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nor2_1
XFILLER_116_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0666_ net186 net298 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_95_3_Left_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1065__D _0086_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_1332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0597_ net186 net316 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and2_1
XFILLER_83_1286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_885 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_2_Right_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1149_ clknet_4_2_0_clk_regs _0170_ VGND VGND VPWR VPWR p_hh_pipe\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_198_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_2_Right_1422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_4_3821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_144_2_Left_1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_1_Right_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold20 p_hh_pipe\[20\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 p_hh_pipe\[14\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold42 p_hh_pipe\[8\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 mid_sum\[12\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 p_ll_pipe\[6\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_1039 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold75 p_ll_pipe\[31\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 p_hh_pipe\[3\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_1525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_4_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_3_3240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_2_Right_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_3_3205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in2[13] net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_189_1_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0632__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_145_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0989__D _0010_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_158_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output79_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_1327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_174_3_Left_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1003_ clknet_4_3_0_clk_regs _0024_ VGND VGND VPWR VPWR p_ll_pipe\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_212_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_1309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_186_3_Right_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0542__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2_3602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_184_3_4089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0718_ p_hl\[7\] net141 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__xor2_2
XFILLER_85_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0649_ net186 net338 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__and2_2
XFILLER_103_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_1_Left_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_200_3_4247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_900 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_3_3599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_1_Right_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_1_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput76 net76 VGND VGND VPWR VPWR p[19] sky130_fd_sc_hd__buf_2
XFILLER_218_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput98 net98 VGND VGND VPWR VPWR p[39] sky130_fd_sc_hd__buf_2
Xoutput87 net87 VGND VGND VPWR VPWR p[29] sky130_fd_sc_hd__buf_2
XFILLER_118_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_in2[12] net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input30_A a[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_4_3321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_188_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_188_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0627__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_3_Right_1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output117_A net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2_3628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_153_1_Left_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_2_Left_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_29_2_Right_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_188_1_Right_1294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_111_1_Right_990 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_1_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_175_3_Left_1372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire156_X net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_228_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_3_3704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_223_2971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_121_2_Right_1409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_3_Right_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_3_Left_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_176_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_217_2775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_1161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_191_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_928 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_2_3593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0995__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_4_3251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_194_3_4193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_230 VGND VGND VPWR VPWR i_add_230/HI net230 sky130_fd_sc_hd__conb_1
Xi_add_241 VGND VGND VPWR VPWR i_add_241/HI net241 sky130_fd_sc_hd__conb_1
XFILLER_213_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_189_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_263 VGND VGND VPWR VPWR i_add_263/HI net263 sky130_fd_sc_hd__conb_1
Xi_add_274 VGND VGND VPWR VPWR i_add_274/HI net274 sky130_fd_sc_hd__conb_1
Xi_add_252 VGND VGND VPWR VPWR i_add_252/HI net252 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_86_1_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_2_3558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_3_Right_1097 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_210_3_4351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0708__A2 net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_1_Right_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_172_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input33_X net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1000__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_227_3082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_205_2_4295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_135_4_Left_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1150__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_1661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0644__X _0102_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_207_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0983_ clknet_4_14_0_clk_regs _0004_ VGND VGND VPWR VPWR p_ll_pipe\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_220_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0820__A p_hl\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_112_1_Right_991 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3_4040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_939 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_3_Left_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_221_2908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_101_2_Left_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[20] net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0554__X _0012_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_110_1_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_219_2859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_184_2_Right_1472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_1_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_188_3_Right_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_3_3210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_3_Right_1129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[19] p_lh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_4_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0730__A p_hl\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1023__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_189_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0905__A p_hl\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_1323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0640__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_196_3_4212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_1_Right_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_225_3019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0639__X _0097_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_201_3_4263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0815__A p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold86_A p_hh_pipe\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_1_Left_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0966_ _0198_ p_hh\[19\] VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__and2_1
XFILLER_179_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1068__D _0089_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1046__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0550__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0897_ p_hl\[27\] p_lh\[27\] VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nor2_1
XFILLER_161_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_113_1_Right_992 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_177_3_Left_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0993__Q p_ll_pipe\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_ll_out[18] p_ll\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_2_3633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_160_1_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_1_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_189_3_Right_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_1_Left_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_191_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1064__Q term_mid\[37\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_2_Left_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_228_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1046 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_3_Right_1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0635__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1069__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xi_hl VGND VPWR clknet_1_0__leaf_clk net8 net19 net20 net21 net22 net24 net25 net9
+ net10 net11 net13 net14 net15 net16 net17 net18 net33 net34 net35 net36 net37 net38
+ net39 net44 net55 net58 net59 net60 net61 net62 net63 net64 p_hl\[0\] p_hl\[10\]
+ p_hl\[11\] p_hl\[12\] p_hl\[13\] p_hl\[14\] p_hl\[15\] p_hl\[16\] p_hl\[17\] p_hl\[18\]
+ p_hl\[19\] p_hl\[1\] p_hl\[20\] p_hl\[21\] p_hl\[22\] p_hl\[23\] p_hl\[24\] p_hl\[25\]
+ p_hl\[26\] p_hl\[27\] p_hl\[28\] p_hl\[29\] p_hl\[2\] p_hl\[30\] p_hl\[31\] p_hl\[3\]
+ p_hl\[4\] p_hl\[5\] p_hl\[6\] p_hl\[7\] p_hl\[8\] p_hl\[9\] net187 mult_16x16
XFILLER_30_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0820_ p_hl\[18\] p_lh\[18\] VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__nor2_1
X_0751_ p_hl\[11\] net153 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__and2_1
XFILLER_115_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0682_ p_hl\[1\] net147 _0203_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a21oi_1
XFILLER_143_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_out[2] p_ll\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_1_Right_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_9_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_16_4_Left_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1165_ clknet_4_5_0_clk_regs _0186_ VGND VGND VPWR VPWR p_hh_pipe\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_48_3_Left_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1096_ clknet_4_9_0_clk_regs _0117_ VGND VGND VPWR VPWR term_low\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_2_3563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0545__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_171_2_Right_1459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_187_3_4124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_209_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3_3989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[7] net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_222_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_2_Left_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_1324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0949_ _0198_ p_hh\[2\] VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_106_1_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_114_1_Right_993 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_178_3_Left_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_143_3_Right_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire135 _0276_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_1
XFILLER_172_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire146 p_lh\[2\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_8
Xwire157 p_hh\[30\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_4
XFILLER_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire168 net125 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_6
Xwire179 net113 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_8
XFILLER_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_144_4_Left_958 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input60_A b[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_883 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_2_3487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload6_A clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_12_0_clk_regs_X clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_4_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_163_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0652__X _0110_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0803_ net135 _0312_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nand2_1
XFILLER_176_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_2_Left_924 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0734_ p_hl\[8\] net140 _0251_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a21o_1
XANTENNA__0756__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0665_ net186 net330 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__and2_1
XFILLER_116_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0596_ net186 net299 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and2_1
XFILLER_124_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_1298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_58_1_Right_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1081__D _0102_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_211_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1148_ clknet_4_2_0_clk_regs _0169_ VGND VGND VPWR VPWR p_hh_pipe\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_214_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_4_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1079_ clknet_4_10_0_clk_regs _0100_ VGND VGND VPWR VPWR term_low\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_4_3816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_820 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold10 p_hh_pipe\[25\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_115_1_Right_994 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold32 p_ll_pipe\[28\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 mid_sum\[32\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold54 p_ll_pipe\[25\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 p_ll_pipe\[2\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 p_ll_pipe\[17\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_40_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold76 p_hh_pipe\[9\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 p_ll_pipe\[29\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_217_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_188_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_179_3_Left_1376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_1272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_200_2_Right_1488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hh_in2[12] net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_177_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1107__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_197_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input63_X net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_171_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_1664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1074 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_1_Left_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0647__X _0105_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire146_A p_lh\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1002_ clknet_4_2_0_clk_regs _0023_ VGND VGND VPWR VPWR p_ll_pipe\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_212_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_2_3663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_165_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3_3940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0542__B p_ll\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2_3603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_934 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_4_3746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1076__D _0097_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_176_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0717_ p_hl\[7\] net141 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_100_2_Left_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0648_ net186 net353 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__and2_1
XFILLER_103_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0579_ net186 net293 VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_57_1_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0557__X _0015_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_1_Right_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_200_3_4248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0717__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_179_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_169_1_Right_1275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_in1[15] net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_2_Left_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net66 VGND VGND VPWR VPWR p[0] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_190_1_Left_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput99 net99 VGND VGND VPWR VPWR p[3] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR p[2] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR p[1] sky130_fd_sc_hd__buf_2
XFILLER_114_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[11] net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_1_Right_995 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_A a[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0671__A2 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0643__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_2_3527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_4_3676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output91_A net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_201_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_171_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_228_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_2_4005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire149_X net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_127_3_3705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_3_Left_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_223_2972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_182_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0553__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_191_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0996__Q p_ll_pipe\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_4_3246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_194_3_4194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_add_242 VGND VGND VPWR VPWR i_add_242/HI net242 sky130_fd_sc_hd__conb_1
Xi_add_220 VGND VGND VPWR VPWR i_add_220/HI net220 sky130_fd_sc_hd__conb_1
Xi_add_231 VGND VGND VPWR VPWR i_add_231/HI net231 sky130_fd_sc_hd__conb_1
XANTENNA__0728__A _0244_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_2_3492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_275 VGND VGND VPWR VPWR i_add_275/HI net275 sky130_fd_sc_hd__conb_1
Xi_add_264 VGND VGND VPWR VPWR i_add_264/HI net264 sky130_fd_sc_hd__conb_1
Xi_add_253 VGND VGND VPWR VPWR i_add_253/HI net253 sky130_fd_sc_hd__conb_1
XFILLER_199_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_153_4_Left_967 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_1286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_202_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_2_3457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_4_Left_904 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_210_3_4352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_1_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_11_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_29_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_2_4296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_X net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_190_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_1_Right_996 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0638__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_4_Left_899 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_165_2_Right_1453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0982_ clknet_4_9_0_clk_regs _0003_ VGND VGND VPWR VPWR p_ll_pipe\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_220_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_212_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0820__B p_lh\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_4_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_179_3_4041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0548__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0570__X _0028_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[18] p_lh\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_178_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0730__B net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_189_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_201_1_Left_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0905__B p_lh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_1_Left_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_4_3751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_196_3_4213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_1_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_229_3189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_3_4264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_1_Right_997 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0815__B net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold79_A p_ll_pipe\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0965_ _0198_ p_hh\[18\] VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_66_1_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0896_ _0198_ _0396_ _0397_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__and3_1
XANTENNA__0831__A p_hl\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_179_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0550__B p_ll\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_207_2_4315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_161_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1084__D _0105_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_3_Right_1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_999 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_ll_out[17] p_ll\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_2_Left_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_1_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_2_3532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_4_3681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_1314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_3_3710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_1582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0651__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0750_ p_hl\[11\] net153 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__nor2_1
XFILLER_7_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_3_Left_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0681_ p_hl\[2\] net146 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__nor2_1
XFILLER_115_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire176_A net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_out[1] p_ll\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_1_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1164_ clknet_4_4_0_clk_regs _0185_ VGND VGND VPWR VPWR p_hh_pipe\[23\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_wire131_X net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_1_Right_998 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1095_ clknet_4_8_0_clk_regs _0116_ VGND VGND VPWR VPWR term_low\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_4_3216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_209_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1013__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0545__B p_ll\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[6] net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_2_3462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1079__D _0100_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0561__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0948_ _0198_ p_hh\[1\] VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__and2_1
XFILLER_179_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_1336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_807 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0879_ _0380_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__and3_1
XFILLER_118_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_2_4075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_162_4_Left_976 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_140_1_Right_1246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_4_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_2_Right_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_212_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire136 _0230_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_1
XFILLER_71_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire147 p_lh\[1\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_6
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire169 net124 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_6
XFILLER_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire158 p_hh\[29\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_4
XFILLER_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_165_2_Left_1180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_1201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_1212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_895 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input53_A b[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1036__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0646__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_2_3488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0802_ _0250_ _0275_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__nor3_1
XFILLER_106_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0733_ _0248_ _0250_ _0252_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a21oi_1
XFILLER_171_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0664_ net186 net336 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__and2_1
XFILLER_115_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire179_X net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0595_ net186 net306 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and2_1
XFILLER_6_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_3_3639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0556__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1147_ clknet_4_0_0_clk_regs _0168_ VGND VGND VPWR VPWR p_hh_pipe\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1078_ clknet_4_11_0_clk_regs _0099_ VGND VGND VPWR VPWR term_low\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_1351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0999__Q p_ll_pipe\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_1_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_1_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_105_1_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_4_3721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold22 term_low\[0\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__1059__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold11 p_hh_pipe\[5\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold33 mid_sum\[8\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold44 p_ll_pipe\[30\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 mid_sum\[11\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold77 p_hh_pipe\[30\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 mid_sum\[22\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 p_hh_pipe\[17\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[15] net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_1284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_143_1_Left_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_81_2_Right_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hh_in2[11] net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_166_2_Left_1181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_1086 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0910__A1 p_hl\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_970 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_212_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_3_3569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1001_ clknet_4_3_0_clk_regs _0022_ VGND VGND VPWR VPWR p_ll_pipe\[22\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_wire139_A p_lh\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_169_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_3_Left_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_169_3_3941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0716_ _0194_ _0195_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand2_1
XFILLER_116_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0647_ net186 net340 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_71_2_3502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0578_ net186 net371 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__and2_1
XFILLER_58_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_200_3_4249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_183_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0901__A1_N p_hl\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_in1[14] net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_957 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_194_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput67 net67 VGND VGND VPWR VPWR p[10] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_117_2_3668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput78 net78 VGND VGND VPWR VPWR p[20] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR p[30] sky130_fd_sc_hd__buf_2
XFILLER_118_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[10] net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_125_4_Left_939 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_3_3499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_201_1_Right_1307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A a[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_3_Left_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_4_3221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_3_4130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1008 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_2_Right_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_2_3528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output84_A net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_2_Left_1182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_2_4006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0553__B p_ll\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1087__D _0108_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_217_2788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_4_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input8_A a[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_213_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_146_2_Right_1434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_190_1_Right_1296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_221 VGND VGND VPWR VPWR i_add_221/HI net221 sky130_fd_sc_hd__conb_1
Xi_add_232 VGND VGND VPWR VPWR i_add_232/HI net232 sky130_fd_sc_hd__conb_1
XANTENNA__0728__B _0247_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xi_add_210 VGND VGND VPWR VPWR i_add_210/HI net210 sky130_fd_sc_hd__conb_1
XFILLER_2_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_2_3493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xi_add_243 VGND VGND VPWR VPWR i_add_243/HI net243 sky130_fd_sc_hd__conb_1
XFILLER_113_1270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_265 VGND VGND VPWR VPWR i_add_265/HI net265 sky130_fd_sc_hd__conb_1
Xi_add_254 VGND VGND VPWR VPWR i_add_254/HI net254 sky130_fd_sc_hd__conb_1
Xi_add_276 VGND VGND VPWR VPWR i_add_276/HI net276 sky130_fd_sc_hd__conb_1
XFILLER_187_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_2_3458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_3_4353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_211_1_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_993 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_1_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_227_3084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_3_3644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input19_X net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output122_A net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0654__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_106_1_Left_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0981_ clknet_4_13_0_clk_regs _0002_ VGND VGND VPWR VPWR p_ll_pipe\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_3_3609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_2_Right_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_212_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3_4042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_168_2_Left_1183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire161_X net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_134_1_Right_1240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0548__B p_ll\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_1_Right_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_1_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0564__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_196_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_219_2839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_2_3975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1168__Q p_hh_pipe\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_152_1_Left_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_156_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_1_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_2_Left_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_3_3574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_963 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_215_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_204_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_196_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_196_3_4214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_3_Right_1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0649__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_3_Left_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_2_Left_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_221_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0964_ _0198_ p_hh\[17\] VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__and2_1
XFILLER_9_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0895_ _0395_ net137 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nand2_1
XANTENNA__0831__B p_lh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_2_Right_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_1321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_207_2_4316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_172_3_Right_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_1297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_190_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0559__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_169_2_Left_1184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_out[16] p_ll\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1092__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_1_Right_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_215_Left_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_223_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0581__X _0039_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_1191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_2_3533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_4_Left_948 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_1_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_224_Left_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_219_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_224_3010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_164_2_3887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_1_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_206_1_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_228_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_1594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_204_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_175_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0680_ p_hl\[2\] net146 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nand2_1
XFILLER_116_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_121_1_Right_1227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire169_A net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[0] p_ll\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_1284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1163_ clknet_4_5_0_clk_regs _0184_ VGND VGND VPWR VPWR p_hh_pipe\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_4_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1094_ clknet_4_11_0_clk_regs _0115_ VGND VGND VPWR VPWR term_low\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_206_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[5] net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_ll_in1[9] net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_2_3463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_1304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0561__B p_ll\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0947_ _0198_ p_hh\[0\] VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_80_1_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_819 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0878_ _0361_ _0368_ _0369_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_85_2_Right_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_183_2_4076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_173_3_Right_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_1267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_196_2_Right_1484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0736__B net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_216_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_1_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_1_Right_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_3_3614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_1363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload0 clknet_1_1__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_16
XFILLER_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire148 p_lh\[17\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_4
XFILLER_197_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire159 p_hh\[28\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_4
XFILLER_197_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input46_A b[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_115_1_Left_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0927__A p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_210_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_201_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_1296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_2_3387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_163_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0662__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_3_Right_1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0801_ _0284_ _0290_ _0294_ _0303_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__nand4_2
XFILLER_176_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0732_ _0250_ _0248_ net186 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o21ai_1
XFILLER_176_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0663_ net186 net332 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__and2_1
XFILLER_87_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0594_ net186 net302 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__and2_1
XFILLER_48_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_1324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_1_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_184_1_Right_1290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in3[29] term_low\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0837__A p_hl\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1146_ clknet_4_12_0_clk_regs _0167_ VGND VGND VPWR VPWR p_hh_pipe\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0556__B p_ll\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1077_ clknet_4_10_0_clk_regs _0098_ VGND VGND VPWR VPWR term_low\[1\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__1130__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_161_1_Left_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_1347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0572__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_2_Left_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_1_Left_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_2_Right_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0998__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_205_2_Left_1220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3_4027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold23 mid_sum\[10\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 mid_sum\[2\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_212_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_174_3_Right_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_129_4_3716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold34 p_hh_pipe\[23\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 p_ll_pipe\[10\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 p_ll_pipe\[3\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold89 p_hh_pipe\[4\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 p_ll_pipe\[12\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 p_ll_pipe\[1\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[14] net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_202_3_4270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_1_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_1_Right_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hh_in2[10] net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_158_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_3_Right_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1003__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input49_X net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_3_Right_1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_102_2_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_1098 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_2_Left_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0657__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0910__A2 p_lh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1153__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1000_ clknet_4_3_0_clk_regs _0021_ VGND VGND VPWR VPWR p_ll_pipe\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_169_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_load_slew186_A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_206_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3_3942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_1_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_176_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0715_ _0231_ _0235_ _0236_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__o21a_1
XFILLER_117_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_176_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0646_ net186 net344 VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_71_2_3503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0577_ net186 net368 VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__and2_1
XFILLER_58_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0567__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_165_2_3892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_4_Left_957 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1129_ clknet_4_2_0_clk_regs _0150_ VGND VGND VPWR VPWR mid_sum\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_in1[13] net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_2_Right_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput68 net68 VGND VGND VPWR VPWR p[11] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR p[21] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_155_3_Right_1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_206_2_Left_1221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_175_3_Right_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_4_Left_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_188_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_1_Right_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_4_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_127_2_Right_1415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_2_3427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_171_1_Right_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output77_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_103_2_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_217_2789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0629_ net186 net342 VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__and2_2
XFILLER_113_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_994 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_222 VGND VGND VPWR VPWR i_add_222/HI net222 sky130_fd_sc_hd__conb_1
Xi_add_200 VGND VGND VPWR VPWR i_add_200/HI net200 sky130_fd_sc_hd__conb_1
Xi_add_233 VGND VGND VPWR VPWR i_add_233/HI net233 sky130_fd_sc_hd__conb_1
Xi_add_211 VGND VGND VPWR VPWR i_add_211/HI net211 sky130_fd_sc_hd__conb_1
XFILLER_6_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_244 VGND VGND VPWR VPWR i_add_244/HI net244 sky130_fd_sc_hd__conb_1
Xi_add_255 VGND VGND VPWR VPWR i_add_255/HI net255 sky130_fd_sc_hd__conb_1
XFILLER_148_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_266 VGND VGND VPWR VPWR i_add_266/HI net266 sky130_fd_sc_hd__conb_1
XFILLER_113_1282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xi_add_277 VGND VGND VPWR VPWR i_add_277/HI net277 sky130_fd_sc_hd__conb_1
XANTENNA__0584__X _0042_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0744__B net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_2_3392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_165_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_1_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_1_Left_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0760__A _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_167_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_2_Right_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_210_3_4354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_3_4337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_2_3357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_972 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_961 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_3085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_207_2_Left_1222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_227_3074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_190_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_3_Right_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_3_3645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output115_A net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0980_ clknet_4_9_0_clk_regs _0001_ VGND VGND VPWR VPWR p_ll_pipe\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_158_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_1_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0670__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_1_Right_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_3_Right_1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0669__X _0127_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3_4043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire154_X net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_942 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_2_3647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_2_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_2_Left_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1098__D _0119_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_173_2_3976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0580__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_149_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[16] p_lh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_3_Right_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_3_3575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_975 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_3_Left_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_185_3_4097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_2_Right_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input31_X net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_208_2_Left_1223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0665__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_2_4165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_1_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_177_3_Right_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0952__X _0167_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0963_ _0198_ p_hh\[16\] VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__and2_1
XFILLER_220_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0894_ net137 _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_76_1_Right_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_152_4_Left_966 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_1276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[9] net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0559__B p_ll\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_4_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_out[15] p_ll\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0575__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_2_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_223_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_168_3_3927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_1_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_4_Left_898 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_2_3432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0931__A_N p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_3011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_2_3888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_4_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0932__B p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_13_2_Right_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_177_2_Right_1465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0947__X _0162_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1162_ clknet_4_4_0_clk_regs _0183_ VGND VGND VPWR VPWR p_hh_pipe\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_209_2_Left_1224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1093_ clknet_4_10_0_clk_regs _0114_ VGND VGND VPWR VPWR term_low\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_178_3_Right_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_in1[8] net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[4] net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold84_A p_hh_pipe\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0946_ _0436_ _0440_ net187 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__a21oi_1
XFILLER_220_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_1_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0877_ _0354_ _0363_ _0370_ _0362_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_43_2_3362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_1_Right_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_1_Left_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_2_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1071 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_1_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_221_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_2_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_3_3615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0752__B net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_4_0_0_clk_regs VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_8
XFILLER_109_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire149 p_lh\[15\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_4
XFILLER_197_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_165_1_Right_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_2_3652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input39_A b[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_1_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0927__B p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_3_Left_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_2_3388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0800_ _0310_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nor2_1
XANTENNA__1082__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0731_ _0244_ _0247_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a21oi_1
XFILLER_7_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_2_Left_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0662_ net186 net328 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__and2_1
XANTENNA_wire181_A net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0593_ net186 net374 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__and2_1
XFILLER_124_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_2_Right_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_3_3580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0837__B p_lh\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_160_3_Left_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1145_ clknet_4_4_0_clk_regs _0166_ VGND VGND VPWR VPWR p_hh_pipe\[4\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0677__C1 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1076_ clknet_4_10_0_clk_regs _0097_ VGND VGND VPWR VPWR term_low\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_181_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_179_3_Right_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_3_3539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0572__B p_ll\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0929_ p_hl\[30\] p_lh\[30\] VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2b_1
XFILLER_107_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_197_3_4220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_3_Right_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_1_Right_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_197_1_Right_1303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_206_2_Right_1494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3_4028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold13 p_hh_pipe\[31\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold24 p_hh_pipe\[21\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 p_ll_pipe\[23\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold35 mid_sum\[29\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold79 p_ll_pipe\[20\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold68 mid_sum\[30\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 mid_sum\[25\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_112_1122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0747__B net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[13] net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_202_3_4271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_3_Left_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_2_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_200_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_8_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_153_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0938__A p_hl\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_1315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_169_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload4_A clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_165_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_161_4_Left_975 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_3_3469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_lh_out[9] p_lh\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_4_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_169_3_3943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_3_Right_1106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0714_ _0231_ _0235_ net187 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire184_X net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0645_ net186 net335 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__and2_1
XFILLER_116_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_2_Right_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0576_ net186 net367 VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_9_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0848__A p_hl\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_2_3893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_2_3402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_187_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_161_3_Left_1358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1128_ clknet_4_1_0_clk_regs _0149_ VGND VGND VPWR VPWR mid_sum\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_226_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0583__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1059_ clknet_4_15_0_clk_regs _0080_ VGND VGND VPWR VPWR term_mid\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[12] net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_198_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_194_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_152_1_Right_1258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_200_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_970 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_1_Right_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput69 net69 VGND VGND VPWR VPWR p[12] sky130_fd_sc_hd__buf_2
XFILLER_118_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_188_3_4132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_3_3399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_2_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_175_3_3997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_3_Left_1320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_185_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input61_X net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1120__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_2_3428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0668__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_add_in1[57] term_high\[57\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire144_A p_lh\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_184_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_223_2953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_223_2975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_1_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_3_3620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0988__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_142_1_Left_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_176_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_929 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0628_ net186 net348 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__and2_2
XANTENNA__0578__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0559_ _0198_ p_ll\[17\] VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__and2_1
XFILLER_113_962 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_2_Right_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_223 VGND VGND VPWR VPWR i_add_223/HI net223 sky130_fd_sc_hd__conb_1
Xi_add_201 VGND VGND VPWR VPWR i_add_201/HI net201 sky130_fd_sc_hd__conb_1
Xi_add_212 VGND VGND VPWR VPWR i_add_212/HI net212 sky130_fd_sc_hd__conb_1
XFILLER_6_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_245 VGND VGND VPWR VPWR i_add_245/HI net245 sky130_fd_sc_hd__conb_1
Xi_add_256 VGND VGND VPWR VPWR i_add_256/HI net256 sky130_fd_sc_hd__conb_1
Xi_add_234 VGND VGND VPWR VPWR i_add_234/HI net234 sky130_fd_sc_hd__conb_1
XFILLER_6_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_278 VGND VGND VPWR VPWR i_add_278/HI net278 sky130_fd_sc_hd__conb_1
XFILLER_187_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_267 VGND VGND VPWR VPWR i_add_267/HI net267 sky130_fd_sc_hd__conb_1
XFILLER_214_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_3_Left_1359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_2_3393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_3_Right_1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_3_4338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1143__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_2_3358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_3_Left_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_227_3086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_3075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A a[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output108_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_3_3550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_3_3544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_2_Left_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_2_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0951__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_212_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_3_Left_1321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_3_3509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3_4044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_3_4050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_ll_out[31] p_ll\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_2_3648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire147_X net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_987 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1016__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_4_Left_938 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_7_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_1238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0580__B p_hh_pipe\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_149_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_3_Left_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_1318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_3_3474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_3_4098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_154_1_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_229_3159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_4_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1039__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input24_X net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_4_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_192_2_4166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_158_2_3857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0962_ net186 p_hh\[15\] VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__and2_1
XFILLER_220_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_214_2705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0893_ _0394_ _0385_ _0393_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__o21ai_1
XFILLER_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_3_Left_1322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_hl_in1[8] net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_229_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[14] p_ll\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_1324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_227_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_10_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_184_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0591__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3_3928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_158_2_Right_1446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_108_1_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_1306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_219_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_2_3433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_1_Left_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_224_3012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_3_Right_1090 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_1153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2_3787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_204_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_regs_0_clk_X delaynet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[59] net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_1_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_4_Right_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1161_ clknet_4_4_0_clk_regs _0182_ VGND VGND VPWR VPWR p_hh_pipe\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1092_ clknet_4_8_0_clk_regs _0113_ VGND VGND VPWR VPWR term_low\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[7] net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_151_1_Left_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[3] net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_187_3_4117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_220_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_2_Left_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0945_ _0439_ _0441_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_146_1_Right_1252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_211_3_4360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0876_ _0341_ _0348_ _0349_ _0376_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a31o_1
XFILLER_9_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_2_3363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_3_Left_1323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0586__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_1_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload2 clknet_4_1_0_clk_regs VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
Xwire139 p_lh\[9\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_4
XFILLER_165_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_3_3514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_1272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_2_Left_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_149_1_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0686__B1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_185_2_Left_1200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_3_Right_1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_156_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0730_ p_hl\[8\] net140 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__xnor2_4
XFILLER_7_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_2_3287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0661_ net186 net341 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__and2_2
XFILLER_48_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0592_ net186 net366 VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
XFILLER_217_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire174_A net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_1296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_hh_out[9] p_hh\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_4_Right_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_133_4_Left_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1144_ clknet_4_12_0_clk_regs _0165_ VGND VGND VPWR VPWR p_hh_pipe\[3\] sky130_fd_sc_hd__dfxtp_2
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1075_ clknet_4_4_0_clk_regs _0096_ VGND VGND VPWR VPWR term_mid\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_1321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_226_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_2_3657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0928_ p_hl\[30\] p_lh\[30\] VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__nand2_1
XFILLER_107_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0859_ _0364_ _0352_ net138 _0363_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_197_3_4221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_127_3_Left_1324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_178_3_4029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold14 mid_sum\[31\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_216_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold36 p_hh_pipe\[12\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 p_hh_pipe\[15\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 mid_sum\[14\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[12] net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_4_Left_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold58 p_ll_pipe\[8\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_5_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold69 mid_sum\[17\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_112_1134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_202_3_4272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_2_3862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_142_2_Right_1430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_4_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_2_3827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input51_A b[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0938__B p_lh\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_1327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0954__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_169_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0673__B net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_221_2892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_out[8] p_lh\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_186_2_Left_1201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_133_1_Right_1239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3_3944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_3_3950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_176_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0713_ _0233_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__nand2_2
XFILLER_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0644_ net186 net333 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__and2_1
XANTENNA_wire177_X net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0575_ _0198_ net373 VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__and2_2
XFILLER_112_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0848__B p_lh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_135_4_Right_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_2_3403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1127_ clknet_4_2_0_clk_regs _0148_ VGND VGND VPWR VPWR mid_sum\[19\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0864__A p_hl\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_70_2_Right_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_2_3792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1058_ clknet_4_11_0_clk_regs _0079_ VGND VGND VPWR VPWR term_mid\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_114_1_Left_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[11] net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_200_1_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_1_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_207_1_Right_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_198_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_200_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_128_3_Left_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_1297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_170_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1072__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3_3998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_1_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_1661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_205_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_1320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_X net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_171_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0949__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_4_3586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_in1[56] term_high\[56\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_2_3327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_2_Left_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_223_2965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_3_Right_1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_1324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_out[31] p_lh\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_2_Left_1202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_172_1_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0627_ net186 net297 VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and2_1
XFILLER_119_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0558_ _0198_ p_ll\[16\] VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__and2_1
XFILLER_219_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_974 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1095__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_224 VGND VGND VPWR VPWR i_add_224/HI net224 sky130_fd_sc_hd__conb_1
Xi_add_202 VGND VGND VPWR VPWR i_add_202/HI net202 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_194_3_4187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_add_213 VGND VGND VPWR VPWR i_add_213/HI net213 sky130_fd_sc_hd__conb_1
XFILLER_6_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_246 VGND VGND VPWR VPWR i_add_246/HI net246 sky130_fd_sc_hd__conb_1
Xi_add_257 VGND VGND VPWR VPWR i_add_257/HI net257 sky130_fd_sc_hd__conb_1
Xi_add_235 VGND VGND VPWR VPWR i_add_235/HI net235 sky130_fd_sc_hd__conb_1
XFILLER_187_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_279 VGND VGND VPWR VPWR i_add_279/HI net279 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_136_4_Right_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0594__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xi_add_268 VGND VGND VPWR VPWR i_add_268/HI net268 sky130_fd_sc_hd__conb_1
XFILLER_227_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_2_Right_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_214_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_2_Left_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_3_4339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_194_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_182_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_2_3292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_129_3_Left_1326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_227_3087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_2_3257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_227_3098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_1414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A a[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_3_3545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_3_Right_1088 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_142_4_Left_956 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_212_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_212_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output82_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_173_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_3_4051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_4_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_166_3_3899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_ll_out[30] p_ll\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_999 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_regs_X clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_2_Left_933 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_4_Left_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_188_2_Left_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_164_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_195_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_2_3832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0589__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_clk_X clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_219_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A a[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_137_4_Right_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_4_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_3_3475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_2_Right_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_156_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_192_2_Right_1480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_169_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_3_4099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_1_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_1356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_150_2_Left_1165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_201_3_4257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output120_A net172 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input17_X net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_4_3626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0962__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_158_2_3858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_207_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0681__B net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0961_ net186 p_hh\[14\] VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_139_2_Right_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_183_1_Right_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_214_2706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0892_ _0373_ _0374_ _0388_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__or3b_1
XFILLER_118_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[7] net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_154_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1663 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_1_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_i_ll_out[13] p_ll\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_123_1_Left_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_1161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_192_3_Right_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_168_3_3929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_189_2_Left_1204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_4_3591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_224_3002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_1_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_2_3332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input9_X net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_1165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0766__B net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_171_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_219_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_4_3556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_4_Right_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2_3788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_127_1_Right_1233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_73_2_Right_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_199_1_Left_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_204_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[58] net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_2_Left_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1006__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0957__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1156__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_151_2_Left_1166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1160_ clknet_4_12_0_clk_regs _0181_ VGND VGND VPWR VPWR p_hh_pipe\[19\] sky130_fd_sc_hd__dfxtp_2
XFILLER_65_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1091_ clknet_4_8_0_clk_regs _0112_ VGND VGND VPWR VPWR term_low\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[6] net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_3_Right_1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[2] net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_187_3_4118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_215_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0944_ _0198_ _0438_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_211_3_4361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0875_ _0321_ _0316_ _0377_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__o21bai_2
XFILLER_9_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_224_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_192_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_216_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_2_3262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_3_Left_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_3_Right_1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload3 clknet_4_2_0_clk_regs VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__inv_6
XFILLER_101_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_221_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_193_3_Right_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_3_3515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_4_Left_913 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_160_3_3869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_151_3_Right_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_151_4_Left_965 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_139_4_Right_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_2_Right_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_180_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_4_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_2_3288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0660_ net186 net356 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__and2_1
XFILLER_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0591_ _0198_ net370 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_2
XFILLER_217_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_hh_out[8] p_hh\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire167_A p_hh\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_152_2_Left_1167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_123_2_Right_1411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1143_ clknet_4_12_0_clk_regs _0164_ VGND VGND VPWR VPWR p_hh_pipe\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_225_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_4_Left_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1074_ clknet_4_4_0_clk_regs _0095_ VGND VGND VPWR VPWR term_mid\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_66_3_3480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0927_ p_hl\[30\] p_lh\[30\] VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_58_3_3439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0858_ _0345_ _0346_ _0354_ _0355_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_197_3_4222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0789_ p_hl\[15\] net149 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_4_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0597__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold15 mid_sum\[21\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 mid_sum\[15\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_9_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold26 mid_sum\[18\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_229_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_lh_in1[11] net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold48 p_ll_pipe\[26\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 p_ll_pipe\[22\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_1_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_3_4273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0746__A_N net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_168_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_4_3631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_2_3863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0840__A1 p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_190_1_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_194_3_Right_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_197_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_2_3828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2_3670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input44_A b[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_1024 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_1_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0954__B p_hh\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_lh_out[7] p_lh\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0970__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_189_2_Right_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_2_Right_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_170_3_3951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_3_3369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_132_1_Left_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0712_ net142 p_hl\[6\] VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nand2b_1
XFILLER_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0643_ net186 net322 VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and2_1
XFILLER_217_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0574_ _0198_ net352 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_9_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_1310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_4_3561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1126_ clknet_4_3_0_clk_regs _0147_ VGND VGND VPWR VPWR mid_sum\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_153_2_Left_1168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0864__B p_lh\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_202_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1057_ clknet_4_11_0_clk_regs _0078_ VGND VGND VPWR VPWR term_mid\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_145_2_3793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_2_3302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold92_X net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_179_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_in1[10] net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_1_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_18_3_Left_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_2_Right_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_3_Right_1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_2_Left_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_183_3_Left_1380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3_3999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_177_1_Right_1283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_3_3299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_195_3_Right_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input47_X net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0965__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_36_2_3328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_1_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1011__D _0032_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA__0804__A1 _0244_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_lh_out[30] p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_176_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_2_Right_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_3_Left_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_3_3520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_1_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_1189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0626_ net186 net323 VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__and2_1
XFILLER_113_931 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0557_ _0198_ p_ll\[15\] VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__and2_2
XFILLER_218_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_194_3_4188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_add_214 VGND VGND VPWR VPWR i_add_214/HI net214 sky130_fd_sc_hd__conb_1
Xi_add_203 VGND VGND VPWR VPWR i_add_203/HI net203 sky130_fd_sc_hd__conb_1
XFILLER_6_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_247 VGND VGND VPWR VPWR i_add_247/HI net247 sky130_fd_sc_hd__conb_1
Xi_add_225 VGND VGND VPWR VPWR i_add_225/HI net225 sky130_fd_sc_hd__conb_1
Xi_add_236 VGND VGND VPWR VPWR i_add_236/HI net236 sky130_fd_sc_hd__conb_1
XFILLER_2_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_258 VGND VGND VPWR VPWR i_add_258/HI net258 sky130_fd_sc_hd__conb_1
XFILLER_187_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_161_3_3874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_add_269 VGND VGND VPWR VPWR i_add_269/HI net269 sky130_fd_sc_hd__conb_1
XFILLER_54_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1109_ clknet_4_9_0_clk_regs _0130_ VGND VGND VPWR VPWR mid_sum\[1\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_154_2_Left_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_3_Right_1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_2_3293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_160_4_Left_974 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_920 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_997 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_227_3088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_38_2_Right_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_2_3258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_4_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_227_3099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0731__B1 _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_199_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_166_1448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_184_3_Left_1381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_3_3450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_3_3444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_212_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_212_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_196_3_Right_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_190_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0679__B net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_180_3_4052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output75_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_3_3409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1006__D _0027_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_173_2_Right_1461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_184_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_3_Right_1118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_1690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_4_3601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1062__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_153_2_3833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0609_ net186 net284 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__and2_1
XFILLER_8_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_3_3374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_1_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_204_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_196_3_4207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_2_Right_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_141_1_Left_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_201_3_4258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output113_A net179 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0962__B p_hh\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_185_3_Left_1382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0960_ net186 p_hh\[13\] VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_218_2810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1085__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_207_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0891_ p_hl\[25\] p_lh\[25\] _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__o21ai_1
XFILLER_220_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2_3757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_11_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_177_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[6] net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_197_3_Right_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1675 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_1_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[12] p_ll\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire152_X net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_210_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_203_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_2_Left_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_3003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_2_3333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_3_Right_1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_2_4015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_202_2_Right_1490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[57] net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2_3687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[19] p_hl\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0925__B1 p_hl\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0957__B p_hh\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_4_Left_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_160_2_Right_1448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1090_ clknet_4_8_0_clk_regs _0111_ VGND VGND VPWR VPWR term_low\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0973__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_3_Left_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_in1[5] net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[1] net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_187_3_4119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_186_3_Left_1383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0943_ _0425_ _0431_ _0437_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__o21bai_1
XFILLER_220_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_211_3_4362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload10 clknet_4_10_0_clk_regs VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinv_8
XFILLER_105_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0874_ _0317_ _0320_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a21oi_1
XFILLER_122_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_856 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_198_3_Right_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_4_Left_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_1352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_2_3263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_190_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_132_3_Right_1102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_227_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_4_3_0_clk_regs VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
XFILLER_165_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_4_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_1228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_3_3414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_167_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0590_ _0198_ p_hh_pipe\[16\] VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__and2_2
XFILLER_226_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0968__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0687__B net145 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_out[7] p_hh\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0677__A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1142_ clknet_4_0_0_clk_regs _0163_ VGND VGND VPWR VPWR p_hh_pipe\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1073_ clknet_4_5_0_clk_regs _0094_ VGND VGND VPWR VPWR term_mid\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_225_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_1_Left_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold82_A p_ll_pipe\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_147_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_3_Left_1384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0926_ p_hl\[29\] p_lh\[29\] p_hl\[28\] _0422_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a22o_1
XFILLER_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0857_ p_hl\[21\] p_lh\[21\] _0346_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_197_3_4223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0788_ p_hl\[15\] net149 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__and2_1
XFILLER_136_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold16 p_ll_pipe\[27\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 p_hh_pipe\[29\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 mid_sum\[26\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[10] net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_199_3_Right_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold49 p_ll_pipe\[18\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_9_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_115_1_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_3_4274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_1_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0840__A2 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_205_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1146__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_201_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2_3762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_208_2_4325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0788__A p_hl\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1036 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_regs_0_clk clk VGND VGND VPWR VPWR delaynet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_A b[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_132_2_3727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_953 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_2_Left_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0794__Y _0144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[6] p_lh\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_182_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0970__B net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3_3952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0711_ p_hl\[6\] net142 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_109_1_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0642_ net186 net327 VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__and2_1
XFILLER_217_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0573_ net186 p_ll\[31\] VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__and2_1
XFILLER_112_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_1355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1019__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1125_ clknet_4_1_0_clk_regs _0146_ VGND VGND VPWR VPWR mid_sum\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_158_1_Right_1264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_195_1_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1056_ clknet_4_11_0_clk_regs _0077_ VGND VGND VPWR VPWR term_mid\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_2_3303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_2_Left_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold85_X net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_179_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2_3692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_188_3_Left_1385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_918 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0909_ _0384_ _0378_ _0407_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__o21bai_1
XFILLER_107_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_205_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_132_4_Left_946 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_984 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_184_2_4085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0965__B p_hh\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_223_2956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_4_3486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_2_Left_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_2_3227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0804__A2 _0247_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_176_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_4_Left_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_1282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire182_X net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0625_ net186 net290 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and2_1
XFILLER_158_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0556_ _0198_ p_ll\[14\] VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and2_1
XFILLER_119_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_213_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_194_3_4189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_215 VGND VGND VPWR VPWR i_add_215/HI net215 sky130_fd_sc_hd__conb_1
Xi_add_204 VGND VGND VPWR VPWR i_add_204/HI net204 sky130_fd_sc_hd__conb_1
XFILLER_100_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_248 VGND VGND VPWR VPWR i_add_248/HI net248 sky130_fd_sc_hd__conb_1
Xi_add_226 VGND VGND VPWR VPWR i_add_226/HI net226 sky130_fd_sc_hd__conb_1
Xclkbuf_4_7_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_7_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
Xi_add_237 VGND VGND VPWR VPWR i_add_237/HI net237 sky130_fd_sc_hd__conb_1
XFILLER_227_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_259 VGND VGND VPWR VPWR i_add_259/HI net259 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_55_4_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_161_3_3875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1108_ clknet_4_9_0_clk_regs _0129_ VGND VGND VPWR VPWR mid_sum\[0\] sky130_fd_sc_hd__dfxtp_1
X_1039_ clknet_4_6_0_clk_regs _0060_ VGND VGND VPWR VPWR term_high\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_1_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_165_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_224_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_206_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_210_3_4347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_189_3_Left_1386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_2_3915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_194_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_965 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_154_2_Right_1442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_147_2_3802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0731__A1 _0244_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_227_3089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_216_2760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_3_3445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_3_4053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output68_A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0976__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_902 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_113_1_Left_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in1[37] term_high\[37\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0695__B net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire142_A p_lh\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_184_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_146_3_3799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1022__D _0043_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xi_add VGND VPWR clknet_1_0__leaf_clk net188 net198 net199 net200 net201 net202 net203
+ net204 net205 net206 net207 net189 net208 net209 net210 net211 net212 net213 net214
+ net215 net216 net217 net190 net218 net219 term_high\[32\] term_high\[33\] term_high\[34\]
+ term_high\[35\] term_high\[36\] term_high\[37\] term_high\[38\] term_high\[39\]
+ net191 term_high\[40\] term_high\[41\] term_high\[42\] term_high\[43\] term_high\[44\]
+ term_high\[45\] term_high\[46\] term_high\[47\] term_high\[48\] term_high\[49\]
+ net192 term_high\[50\] term_high\[51\] term_high\[52\] term_high\[53\] term_high\[54\]
+ term_high\[55\] term_high\[56\] term_high\[57\] term_high\[58\] term_high\[59\]
+ net193 term_high\[60\] term_high\[61\] term_high\[62\] term_high\[63\] net194 net195
+ net196 net197 net220 net230 net231 net232 net233 net234 net235 term_mid\[16\] term_mid\[17\]
+ term_mid\[18\] term_mid\[19\] net221 term_mid\[20\] term_mid\[21\] term_mid\[22\]
+ term_mid\[23\] term_mid\[24\] term_mid\[25\] term_mid\[26\] term_mid\[27\] term_mid\[28\]
+ term_mid\[29\] net222 term_mid\[30\] term_mid\[31\] term_mid\[32\] term_mid\[33\]
+ term_mid\[34\] term_mid\[35\] term_mid\[36\] term_mid\[37\] term_mid\[38\] term_mid\[39\]
+ net223 term_mid\[40\] term_mid\[41\] term_mid\[42\] term_mid\[43\] term_mid\[44\]
+ term_mid\[45\] term_mid\[46\] term_mid\[47\] term_mid\[48\] net236 net224 net237
+ net238 net239 net240 net241 net242 net243 net244 net245 net246 net225 net247 net248
+ net249 net250 net226 net227 net228 net229 net304 term_low\[10\] term_low\[11\] term_low\[12\]
+ term_low\[13\] term_low\[14\] term_low\[15\] term_low\[16\] term_low\[17\] term_low\[18\]
+ term_low\[19\] term_low\[1\] term_low\[20\] term_low\[21\] term_low\[22\] term_low\[23\]
+ term_low\[24\] term_low\[25\] term_low\[26\] term_low\[27\] term_low\[28\] term_low\[29\]
+ term_low\[2\] term_low\[30\] term_low\[31\] net251 net252 net253 net254 net255 net256
+ net257 net258 term_low\[3\] net259 net260 net261 net262 net263 net264 net265 net266
+ net267 net268 term_low\[4\] net269 net270 net271 net272 net273 net274 net275 net276
+ net277 net278 term_low\[5\] net279 net280 net281 net282 term_low\[6\] term_low\[7\]
+ term_low\[8\] term_low\[9\] net66 net67 net68 net69 net70 net71 net72 net73 net74
+ net75 net76 net77 net78 net79 net80 net81 net82 net83 net84 net85 net86 net87 net88
+ net89 net90 net91 net92 net93 net94 net95 net96 net97 net98 net99 net100 net101
+ net102 net103 net104 net105 net106 net107 net108 net109 net110 net111 net112 net113
+ net114 net115 net116 net117 net118 net119 net120 net121 net122 net123 net124 net125
+ net126 net127 net128 net129 net187 add3x64
XFILLER_224_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_223_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_195_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0608_ net186 net294 VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__and2_1
XFILLER_28_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2_3732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_1_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0539_ p_hl\[15\] VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__inv_2
XFILLER_45_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_189_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_1310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_189_1_Left_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_2_Left_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_3_3375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_196_3_4208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0796__A p_hl\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1107__D _0128_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_3_4259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_out[19] p_hh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output106_A net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_207_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0890_ p_hl\[24\] p_lh\[24\] p_hl\[25\] p_lh\[25\] VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a22o_1
XANTENNA_max_cap187_A net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_4_3526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2_3758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[5] net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_3_Right_1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1017__D _0038_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_ll_out[11] p_ll\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_96_2_Left_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire145_X net145 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_184_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_3_4140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_162_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_195_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_191_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_141_2_Right_1429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_3004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_2_4016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_4_Left_903 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_4_3491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_4_Left_955 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_2_3232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_4_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[56] net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_4_3456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_124_2_3688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_hl_out[18] p_hl\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_178_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0925__A1 p_hl\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_2_Left_932 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_4_Left_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input22_X net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_162_3_3880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0973__B net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1052__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_ll_in1[4] net27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[0] net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_154_3_3839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0942_ _0426_ _0432_ _0437_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_211_3_4363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0873_ _0351_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__or2_1
XFILLER_9_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload11 clknet_4_11_0_clk_regs VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_8
XFILLER_220_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_4_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_868 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_1534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_1364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_205_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_1097 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0852__B1 _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload5 clknet_4_5_0_clk_regs VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
XFILLER_165_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_1218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_182_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_3_3415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1075__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_2_3985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_140_3_3769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_122_1_Left_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[39] net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0601__X _0059_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0968__B net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1141_ clknet_4_0_0_clk_regs _0162_ VGND VGND VPWR VPWR p_hh_pipe\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1072_ clknet_4_4_0_clk_regs _0093_ VGND VGND VPWR VPWR term_mid\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_1_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_3_3380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0925_ p_hl\[29\] p_lh\[29\] p_hl\[28\] _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a22oi_2
XFILLER_31_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_162_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0856_ _0360_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and2b_1
XFILLER_106_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_197_3_4224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0787_ _0196_ _0197_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand2_1
XANTENNA__1098__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_3_3339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold17 p_hh_pipe\[22\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 p_hh_pipe\[13\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_1251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_198_1_Left_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold39 p_ll_pipe\[0\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_9_1397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hh_rst net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_2_Left_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_200_3_Right_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_4_3531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_197_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2_3763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_208_2_4326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0788__B net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1048 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2_3728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_139_1_Right_1245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_161_1_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_out[5] p_lh\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3_3953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0710_ p_hl\[6\] net142 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_73_3_Left_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_908 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output98_A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0641_ net186 net347 VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and2_1
XFILLER_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0572_ _0198_ p_ll\[30\] VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__and2_1
XANTENNA_wire172_A net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_3_3269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_3_Right_1084 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1124_ clknet_4_3_0_clk_regs _0145_ VGND VGND VPWR VPWR mid_sum\[16\] sky130_fd_sc_hd__dfxtp_1
X_1055_ clknet_4_14_0_clk_regs _0076_ VGND VGND VPWR VPWR term_mid\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_179_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_4_3461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_194_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2_3693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_908 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_2_3202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_98_4_Left_912 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0908_ _0379_ _0383_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0889__A p_hl\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0839_ _0345_ _0346_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_150_4_Left_964 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_90_2_Right_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_191_2_Right_1479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_4_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_175_2_Left_1190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_227_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_201_3_Right_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3_3844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_4_Left_896 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_3_3199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_2_4086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_163_3_Right_1133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_223_2968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hl_in1[15] net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_223_2957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_2_3228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_4_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0624_ net186 net308 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__and2_1
XFILLER_158_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire175_X net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_135_2_Right_1423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0725__C1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_3_3420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0555_ _0198_ p_ll\[13\] VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and2_1
XFILLER_113_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1106__Q term_low\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xi_add_205 VGND VGND VPWR VPWR i_add_205/HI net205 sky130_fd_sc_hd__conb_1
XFILLER_100_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_227 VGND VGND VPWR VPWR i_add_227/HI net227 sky130_fd_sc_hd__conb_1
XFILLER_187_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xi_add_238 VGND VGND VPWR VPWR i_add_238/HI net238 sky130_fd_sc_hd__conb_1
Xi_add_216 VGND VGND VPWR VPWR i_add_216/HI net216 sky130_fd_sc_hd__conb_1
XFILLER_226_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_249 VGND VGND VPWR VPWR i_add_249/HI net249 sky130_fd_sc_hd__conb_1
XFILLER_227_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1107_ clknet_4_11_0_clk_regs _0128_ VGND VGND VPWR VPWR term_low\[31\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1038_ clknet_4_6_0_clk_regs _0059_ VGND VGND VPWR VPWR term_high\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3_3774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_3_4348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_1_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_167_2_3916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_147_2_3803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_2_Right_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_1310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1016__Q term_high\[37\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0731__A2 _0247_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_191_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_1332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_131_1_Left_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_2_Left_1191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_199_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_158_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_1_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1009__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_212_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_X net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_3_4054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_3_4037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_3_3350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_3_3344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1159__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0976__B net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_1_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_203_3_4280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_3_3309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_225_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_2_4105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_2_Left_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_4_3501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0607_ net186 net288 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__and2_1
XFILLER_28_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0538_ net141 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
XFILLER_28_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2_3733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2_3664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_3_Right_1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_196_3_4209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_3_3274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0796__B p_lh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_2_Right_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_189_1_Right_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_82_3_Left_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1123__D _0144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_out[18] p_hh\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A a[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_177_2_Left_1192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_218_2812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_in1[4] net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output80_A net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_177_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_1644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_4_Left_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_out[10] p_ll\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_1246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_3_4141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_184_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_1142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_4_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_203_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0897__A p_hl\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_228_3130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_224_3005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_128_3_Right_1098 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input4_A a[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_2_3233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[55] net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_1286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[17] p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0925__A2 p_lh\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0600__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1118__D _0139_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_151_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_2_Right_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0991__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input15_X net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[3] net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_1274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_178_2_Left_1193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0941_ _0434_ _0435_ _0426_ _0432_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__o211ai_1
XFILLER_222_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_211_3_4364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0872_ _0347_ _0356_ _0362_ _0370_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nand4_1
Xclkload12 clknet_4_12_0_clk_regs VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinv_8
XPHY_EDGE_ROW_80_1_Right_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_192_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_1_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_1513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1028__D _0049_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_185_2_Right_1473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_1_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_1303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload6 clknet_4_6_0_clk_regs VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_8
XFILLER_203_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_182_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input7_X net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_82_4_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_3_3314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_2_3986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_add_out[38] net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_178_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_174_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1140_ clknet_4_1_0_clk_regs net131 VGND VGND VPWR VPWR mid_sum\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_93_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_94_2_Right_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1071_ clknet_4_7_0_clk_regs _0092_ VGND VGND VPWR VPWR term_mid\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_1363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_181_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_2_Left_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_179_2_Left_1194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0924_ p_hl\[29\] p_lh\[29\] p_lh\[28\] VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__o21a_1
XFILLER_119_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0855_ p_hl\[22\] p_lh\[22\] VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__nand2_1
XFILLER_119_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_192_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0786_ p_hl\[15\] net149 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_81_1_Right_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold18 mid_sum\[28\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 mid_sum\[16\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_229_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_2_4175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_121_4_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_4_Left_936 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_175_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_3_Left_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_3_Right_1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_193_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1042__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_4_3886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_4_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_1_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[4] p_lh\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_4_Left_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_170_3_3954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3_3937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_109_1_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in1[15] net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0640_ net186 net349 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__and2_1
X_0571_ _0198_ p_ll\[29\] VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__and2_1
XFILLER_217_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire165_A p_hh\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_4_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1123_ clknet_4_13_0_clk_regs _0144_ VGND VGND VPWR VPWR mid_sum\[15\] sky130_fd_sc_hd__dfxtp_1
X_1054_ clknet_4_15_0_clk_regs _0075_ VGND VGND VPWR VPWR term_mid\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_2_Right_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1065__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0907_ _0375_ _0388_ net137 _0400_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nand4b_1
XTAP_TAPCELL_ROW_11_2_3203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_144_3_Right_1114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0889__B p_lh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0838_ p_hl\[20\] p_lh\[20\] VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__and2_1
XFILLER_157_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0769_ _0280_ _0284_ net187 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_82_1_Right_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_1173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_213_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3_3845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_160_1_Right_1266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_964 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_103_1_Left_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_175_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input42_A b[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1126__D _0147_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[14] net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output129_A net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_223_2969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_4_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_200_2_4245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_4_3386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1088__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0623_ net186 net351 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_35_1_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_193_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_3597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0554_ _0198_ p_ll\[12\] VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__and2_1
XFILLER_112_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire168_X net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_206 VGND VGND VPWR VPWR i_add_206/HI net206 sky130_fd_sc_hd__conb_1
XFILLER_26_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_228 VGND VGND VPWR VPWR i_add_228/HI net228 sky130_fd_sc_hd__conb_1
Xi_add_217 VGND VGND VPWR VPWR i_add_217/HI net217 sky130_fd_sc_hd__conb_1
Xi_add_239 VGND VGND VPWR VPWR i_add_239/HI net239 sky130_fd_sc_hd__conb_1
XFILLER_226_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1106_ clknet_4_13_0_clk_regs _0127_ VGND VGND VPWR VPWR term_low\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_2_Right_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1037_ clknet_4_7_0_clk_regs _0058_ VGND VGND VPWR VPWR term_high\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_179_1_Left_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_218_Left_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3_3775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_2_Left_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_3_4349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_201_2_Right_1489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_1_Right_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_227_Left_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_218_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_1344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_184_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2_3702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_199_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_213_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_112_2_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_1_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0603__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_212_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_212_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_3_4230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_3_3345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_86_2_Left_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_179_3_4038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input45_X net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_959 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_203_3_4281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_4_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_3_3699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_2_4106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_out[10] p_lh\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0946__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1103__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0606_ net186 net289 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__and2_1
XFILLER_28_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0537_ p_hl\[7\] VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__inv_2
XFILLER_28_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_2_Right_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_164_4_3891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_189_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_131_4_Left_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_2_Left_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_3_3275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_84_1_Right_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_4_Left_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[17] p_hh\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_2_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1126__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_54_4_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hl_in1[3] net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_4_3426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0620__X _0078_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output73_A net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_118_2_3669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_1258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_224_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_3_4142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_4_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_1676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3_3850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0919__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_205_3_4300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_228_3120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0897__B p_lh\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_228_3131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3_3809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_2_Right_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_4_3391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[54] net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1149__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_168_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_112_1_Left_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_166_2_Right_1454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hl_out[16] p_hl\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_4_3356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_1_Right_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_161_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_ll_in1[2] net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output111_A net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_1_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_1_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_142_3_3780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0940_ _0434_ _0435_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__or2_1
XFILLER_119_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_114_2_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0871_ _0373_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__or2_1
XFILLER_220_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload13 clknet_4_13_0_clk_regs VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_8
XFILLER_220_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3_3739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_188_1_Left_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire150_X net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_87_4_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload7 clknet_4_7_0_clk_regs VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__inv_8
XFILLER_220_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_154_1_Right_1260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_197_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_3_4060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_1299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_2_Right_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_3_3315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_167_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1040__Q term_high\[61\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[37] net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_2_Left_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1129__D _0150_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_1355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0611__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_1279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_174_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_1_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_215_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_873 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_86_1_Right_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1070_ clknet_4_4_0_clk_regs _0091_ VGND VGND VPWR VPWR term_mid\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_185_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_3_Right_1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0923_ _0412_ _0408_ _0419_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__o21bai_1
XFILLER_119_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_4_Left_902 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0854_ p_hl\[22\] p_lh\[22\] VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_140_4_Left_954 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_115_2_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1039__D _0060_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0785_ _0294_ _0297_ _0298_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__o21a_1
XFILLER_192_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_3_3280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_4_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold19 p_hh_pipe\[24\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_229_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_3_3239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_2_4176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_117_2_Left_931 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_197_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_4_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_4_Left_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_4_3431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_175_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1035__Q term_high\[56\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_1274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_978 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_895 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_2_Right_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_4_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_215_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0606__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3_3938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in1[14] net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_221_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_150_3_3820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3_3814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0570_ _0198_ p_ll\[28\] VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__and2_2
XFILLER_139_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1122_ clknet_4_13_0_clk_regs _0143_ VGND VGND VPWR VPWR mid_sum\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_1_Right_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_207_1_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1053_ clknet_4_14_0_clk_regs _0074_ VGND VGND VPWR VPWR term_mid\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_179_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_1_Right_1247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_198_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0906_ _0404_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nor2_1
XFILLER_119_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_2_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_4_3361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0837_ p_hl\[20\] p_lh\[20\] VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nor2_1
XFILLER_116_943 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0768_ _0282_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__nand2_2
XFILLER_1_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0699_ _0217_ _0218_ _0221_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__or3_1
XFILLER_66_1269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_1_Left_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_205_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_177_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_4_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_3_3744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_976 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_171_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0734__A1 p_hl\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_53_1_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_4_3651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_in1[51] term_high\[51\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input35_A b[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hl_in1[13] net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1142__D _0163_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_179_1_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_2959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_200_2_4246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_2_Right_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_197_1_Left_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_170_3_Left_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_2_Left_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0622_ net186 net311 VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__and2_1
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0553_ _0198_ p_ll\[11\] VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_1
XFILLER_112_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2_3598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_1_Right_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_218 VGND VGND VPWR VPWR i_add_218/HI net218 sky130_fd_sc_hd__conb_1
Xi_add_229 VGND VGND VPWR VPWR i_add_229/HI net229 sky130_fd_sc_hd__conb_1
XFILLER_113_1245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xi_add_207 VGND VGND VPWR VPWR i_add_207/HI net207 sky130_fd_sc_hd__conb_1
XFILLER_113_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1105_ clknet_4_14_0_clk_regs _0126_ VGND VGND VPWR VPWR term_low\[29\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_3_Right_1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_3_3320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_1_Right_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1036_ clknet_4_7_0_clk_regs _0057_ VGND VGND VPWR VPWR term_high\[57\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__1032__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_1284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_202_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_3_3674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_2_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_3_Left_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_127_2_3703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_3_4231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_4_Left_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_67_3_Left_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0707__B2 net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_179_3_4039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_X net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_3_3250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_203_3_4282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_4_Left_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_3_3244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload0_A clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_2_Right_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_1_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_4_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_3_3209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_171_3_Left_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire180_X net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold43_A p_ll_pipe\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0605_ net186 net295 VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__and2_1
XFILLER_217_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_1_Right_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_1318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_4_3401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_4_Left_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_1_Right_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1019_ clknet_4_6_0_clk_regs _0040_ VGND VGND VPWR VPWR term_high\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_228_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_202_1_Right_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_2_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_4_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1078__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_133_3_Left_1330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hh_out[16] p_hh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_182_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0614__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_6_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_6_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_177_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[2] net10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output66_A net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire140_A p_lh\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_1_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_1346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_209_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_3_4143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_177_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_2_Right_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_1688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_225_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_147_2_Right_1435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_191_1_Right_1297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_192_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_981 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_172_3_Left_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_205_3_4301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_1_Right_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[53] net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_1_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_out[15] p_hl\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_2_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_195_3_4197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_3_Left_1331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0609__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_ll_in1[1] net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_2_Left_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_1352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output104_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_135_1_Right_1241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_1_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0870_ p_hl\[24\] p_lh\[24\] VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__and2_1
XFILLER_9_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload14 clknet_4_14_0_clk_regs VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_6
XFILLER_9_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0631__X _0089_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire143_X net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_90_3_Right_1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload8 clknet_4_8_0_clk_regs VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_6
XFILLER_203_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_3_Left_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0999_ clknet_4_3_0_clk_regs _0020_ VGND VGND VPWR VPWR p_ll_pipe\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_195_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0701__B net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_3_4061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_1081 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_1_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_1_Right_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1116__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0828__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_3_Right_1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_180_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_142_4_Right_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_4_Left_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[36] net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_3_3214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input65_A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1145__D _0166_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_4_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input20_X net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_135_3_Left_1332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_4_3856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0922_ _0409_ _0413_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0853_ _0358_ _0359_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__nor2_1
XFILLER_119_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0802__A _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0784_ _0297_ _0294_ net187 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_192_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1139__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_202_3_4267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_1_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_1_Right_989 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_1_Right_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2_3637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[2] p_lh\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_122_1_Right_1228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_143_4_3786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_188_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_4_Right_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[19] net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_196_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3_3939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0622__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in1[13] net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_221_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_1_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3_3815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1121_ clknet_4_2_0_clk_regs _0142_ VGND VGND VPWR VPWR mid_sum\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1052_ clknet_4_8_0_clk_regs _0073_ VGND VGND VPWR VPWR term_mid\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_136_3_Left_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_185_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_197_2_Right_1485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0905_ p_hl\[28\] p_lh\[28\] VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__and2_1
XFILLER_119_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_200_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0836_ _0339_ _0340_ _0343_ _0344_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o31a_2
XFILLER_196_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0767_ net152 p_hl\[12\] VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand2b_1
XFILLER_157_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_3_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0698_ _0217_ _0218_ _0220_ _0212_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_135_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2_3567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_212_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_205_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_164_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_1_Left_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_175_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_3_3745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_988 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_2_Left_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in1[50] term_high\[50\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0734__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_195_2_Left_1210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_3_Right_1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_in1[12] net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A a[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_1_Right_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_1_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0617__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_185_1_Right_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_144_4_Right_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_4_3286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output96_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0621_ net186 net319 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__and2_1
XFILLER_109_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0552_ net186 p_ll\[10\] VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__and2_1
XFILLER_193_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2_3653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0725__A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire170_A net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_4_Left_935 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_219 VGND VGND VPWR VPWR i_add_219/HI net219 sky130_fd_sc_hd__conb_1
Xi_add_208 VGND VGND VPWR VPWR i_add_208/HI net208 sky130_fd_sc_hd__conb_1
XFILLER_26_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_2_3497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1104_ clknet_4_13_0_clk_regs _0125_ VGND VGND VPWR VPWR term_low\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_90_3_Left_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1035_ clknet_4_7_0_clk_regs _0056_ VGND VGND VPWR VPWR term_high\[56\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_137_3_Left_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_3_3675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_190_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0819_ _0198_ _0328_ _0329_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__and3_1
XFILLER_172_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_4_Left_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_3_Right_1094 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_4_3861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_87_3_Right_1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_216_2742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_4_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_216_2753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_3_4232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_4_3826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_210_3_Left_1407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0707__A2 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_196_2_Left_1211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0994__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_203_3_4283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_188_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_3_3245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_1_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_116_1_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0891__A1 p_hl\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_1_Right_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_145_4_Right_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0604_ net186 net359 VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and2_1
XFILLER_217_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire173_X net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_2_3642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_144_4_3791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1018_ clknet_4_6_0_clk_regs _0039_ VGND VGND VPWR VPWR term_high\[39\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_156_3_Right_1126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_102_1_Left_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_3_Left_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_202_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2_3607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hl_out[31] p_hl\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_171_3_3961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_163_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_out[15] p_hh\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_2_Right_1416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_1_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_172_1_Right_1278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_183_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_hl_in1[1] net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_211_3_Left_1408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0630__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_X net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_178_1_Left_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_194_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1022__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_4_3326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_197_2_Left_1212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0629__X _0087_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2_3572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_3_4144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_3_4150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_1_Right_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_4_Right_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1058__D _0079_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_136_3_3750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0540__A net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_228_3111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_3_4302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_228_3122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1144__Q p_hh_pipe\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_210_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_3_3709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_210_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_2_Left_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_139_3_Left_1336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[52] net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_4_3291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1045__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_4_3256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_195_3_4198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_3_Right_1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in1[0] net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A a[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_221_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0625__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_1_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_130_4_Left_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload15 clknet_4_15_0_clk_regs VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__inv_6
XFILLER_127_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_122_3_3680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_190_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_3_Right_1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_198_2_Left_1213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_2_Left_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_225_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_1_Right_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1068__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_4_Left_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload9 clknet_4_9_0_clk_regs VGND VGND VPWR VPWR clkload9/X sky130_fd_sc_hd__clkbuf_8
XFILLER_203_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0998_ clknet_4_0_0_clk_regs _0019_ VGND VGND VPWR VPWR p_ll_pipe\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_203_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_4_3831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_147_4_Right_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0541__Y _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_3_4062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_140_3_Right_1110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A a[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_4_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_227_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[35] net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_3_3215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_160_2_Left_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input58_A b[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_172_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input13_X net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_226_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0921_ _0404_ _0405_ _0416_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__or3b_1
XFILLER_226_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2_3612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0642__X _0100_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0852_ net138 _0355_ _0357_ _0198_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__o31ai_1
XFILLER_200_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0783_ _0280_ _0284_ _0290_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_155_1_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_3_4217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_1_Left_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_202_3_4268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_199_2_Left_1214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0552__X _0010_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_4_Right_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2_3671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_1_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_4_3331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input5_X net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_2_3638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_out[1] p_lh\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_178_2_Right_1466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_1_Left_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_993 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_161_2_Left_1176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[18] net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in1[12] net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_2_4025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3_3720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3_3714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1120_ clknet_4_3_0_clk_regs _0141_ VGND VGND VPWR VPWR mid_sum\[12\] sky130_fd_sc_hd__dfxtp_1
X_1051_ clknet_4_9_0_clk_regs _0072_ VGND VGND VPWR VPWR term_mid\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_207_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1081 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0904_ p_hl\[28\] p_lh\[28\] VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nor2_1
XANTENNA_clkbuf_4_0_0_clk_regs_X clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0835_ _0331_ _0337_ _0342_ _0198_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o31a_1
XFILLER_119_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0766_ p_hl\[12\] net152 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__nand2b_1
XFILLER_227_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1066__D _0087_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_196_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0697_ p_hl\[3\] net145 _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__o21ai_1
XFILLER_116_978 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_4_3261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_94_2_Left_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_211_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_2_3568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_166_1_Right_1272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_3_4129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_3_Left_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_4_Left_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_214_2681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_149_4_Right_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_1338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_87_4_Left_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_hl_in1[11] net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_1_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_4_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0633__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1129__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_162_2_Left_1177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0620_ net186 net329 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and2_1
XFILLER_109_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output89_A net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0551_ net186 p_ll\[9\] VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__and2_1
XFILLER_193_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_2_Left_930 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire163_A p_hh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_4_Left_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_209 VGND VGND VPWR VPWR i_add_209/HI net209 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_70_2_3498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_1258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1103_ clknet_4_15_0_clk_regs _0124_ VGND VGND VPWR VPWR term_low\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_213_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1034_ clknet_4_7_0_clk_regs _0055_ VGND VGND VPWR VPWR term_high\[55\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_68_3_Right_1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_198_1_Right_1304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_207_2_Right_1495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_3_3220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0543__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput60 b[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_8
X_0818_ _0308_ _0323_ _0327_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_62_4_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1147__Q p_hh_pipe\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0749_ _0261_ _0263_ _0264_ _0266_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o31a_1
XFILLER_104_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_207_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0724__Y _0244_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_2_3658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_216_2743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_212_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0740__X _0138_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_212_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_3_4233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_3_4047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input40_A b[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_162_2_Right_1450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_214_Left_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_203_3_4284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_137_3_Right_1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output127_A net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0628__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_116_1_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0891__A2 p_lh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_223_Left_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_218_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_163_2_Left_1178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0650__X _0108_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_209_2_4335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_201_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0603_ net186 net309 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and2_1
XFILLER_193_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_227_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire166_X net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_153_1_Right_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0538__A net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_2_3643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1017_ clknet_4_15_0_clk_regs _0038_ VGND VGND VPWR VPWR term_high\[38\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_4_3301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_2_Right_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_1_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2_3608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hl_out[30] p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_171_3_3962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_193_3_Left_1390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_176_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_196_1_Left_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_2_Left_1140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[14] p_hh\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_2_Left_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_183_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_201_1_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_1235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in1[0] net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_190_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input43_X net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_1331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2_3573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_190_3_4151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0645__X _0103_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_71_3_Left_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0821__A p_hl\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_185_2_4095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_164_2_Left_1179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_228_3134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_3_4303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_3_Right_1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_228_3123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_3009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkload12_A clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_118_1_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_34_4_Left_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_3_Left_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1160__Q p_hh_pipe\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[51] net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_159_4_Left_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_2_Right_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_1_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_4_Left_910 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_194_3_Left_1391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_4_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_195_3_4199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_2_Left_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1070__Q term_mid\[43\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_1_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_211_3_4357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0641__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1159__D _0180_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_4_Left_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_2_3925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output71_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1069__D _0090_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0997_ clknet_4_2_0_clk_regs _0018_ VGND VGND VPWR VPWR p_ll_pipe\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_118_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0551__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_181_3_4063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1012__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[34] net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_49_2_Right_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_1_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1162__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_1358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_195_3_Left_1392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_215_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_1583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_2_Left_1142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0636__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0920_ _0416_ _0417_ _0418_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__o21a_1
XFILLER_221_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2_3613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0851_ net138 _0355_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__o21a_1
XFILLER_200_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_4_3756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0782_ _0287_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nand2_1
XFILLER_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_197_3_4218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_210_1_Left_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_1_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_202_3_4269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_159_2_Right_1447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_4
XANTENNA__1035__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0546__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0691__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_1330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_1_Left_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_197_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_200_2_Left_1215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_965 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_976 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_2_Left_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_1_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_959 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0727__Y _0247_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_out[0] p_lh\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_2_3537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_4_3686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[17] net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_196_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_170_3_3947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in1[11] net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_in1[9] net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_196_3_Left_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_1_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_2_4026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_147_1_Right_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1058__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_129_3_3715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_3_Left_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ clknet_4_9_0_clk_regs _0071_ VGND VGND VPWR VPWR term_mid\[23\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_128_2_Left_1143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0653__X _0111_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0903_ _0401_ _0400_ _0403_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0834_ _0336_ _0332_ _0331_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a21oi_1
XFILLER_204_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_957 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0765_ p_hl\[12\] net152 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nand2_1
X_0696_ _0211_ _0210_ _0206_ _0213_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__o211ai_4
XFILLER_48_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_4_Left_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1082__D _0103_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0900__A1 p_hl\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_2_3467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_4_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_178_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_201_2_Left_1216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_193_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_170_3_Right_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_3_Right_1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hl_in1[10] net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0550_ net186 p_ll\[8\] VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__and2_1
XFILLER_193_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_197_3_Left_1394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0648__X _0106_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1102_ clknet_4_15_0_clk_regs _0123_ VGND VGND VPWR VPWR term_low\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_213_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_213_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1033_ clknet_4_7_0_clk_regs _0054_ VGND VGND VPWR VPWR term_high\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_129_2_Left_1144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_2_3397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_175_2_3995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0543__B p_ll\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_1_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_1650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1077__D _0098_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput61 b[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_8
XFILLER_200_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0817_ _0308_ _0323_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__or3_1
Xinput50 b[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_4
X_0748_ _0261_ _0265_ net187 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_143_2_Right_1431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0679_ p_hl\[2\] net146 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__and2_1
XFILLER_44_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0718__B net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_222_2940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_1_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_217_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_1321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_216_2766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_4_3761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_202_2_Left_1217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_198_3_4234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_171_3_Right_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_3_4048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_131_4_3726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input33_A b[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_982 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_189_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0644__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_189_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_191_1_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_2_4336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0602_ net186 net365 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and2_1
XFILLER_193_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_226_3073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_198_3_Left_1395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_226_3062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0819__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire159_X net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_208_1_Right_1314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_226_3051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1016_ clknet_4_15_0_clk_regs _0037_ VGND VGND VPWR VPWR term_high\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_223_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_2_Left_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0554__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_2_3542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_4_3691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_163_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_2_3507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0729__A _0244_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1119__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[13] p_hh\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_183_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_218_2806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_3_Right_1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_203_2_Left_1218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0639__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input36_X net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_216_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_190_3_4152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_4_3226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_2_3472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_4_Left_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_220_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0661__X _0119_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_940 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0821__B p_lh\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_185_2_4096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_130_2_Right_1418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_205_3_4304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0549__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_4_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_199_3_Left_1396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1090__D _0111_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0836__X _0148_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_167_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[50] net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_1_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_146_4_3801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_3_Right_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1091__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_211_3_4358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_168_2_3926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_204_2_Left_1219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_1_Left_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_186_1_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_1059 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0832__A p_hl\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0996_ clknet_4_1_0_clk_regs _0017_ VGND VGND VPWR VPWR p_ll_pipe\[17\] sky130_fd_sc_hd__dfxtp_2
XFILLER_118_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0551__B p_ll\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_1_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1085__D _0106_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_193_2_Right_1481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_181_3_4064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_4_3731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_2_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_204_3_4290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_5_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_5_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_55_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_177_1_Left_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[33] net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_187_2_4115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_3_3579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in1[9] net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0917__A p_hl\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_190 VGND VGND VPWR VPWR i_add_190/HI net190 sky130_fd_sc_hd__conb_1
XANTENNA_clkbuf_4_12_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output102_A net183 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0652__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_147_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0850_ _0352_ _0347_ _0346_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a21oi_1
XFILLER_200_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0781_ p_hl\[13\] net151 p_hl\[12\] net152 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_197_3_4219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_2_3512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_2_Left_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire141_X net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_1_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_4
XFILLER_168_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0546__B p_ll\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0562__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_4_Left_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0979_ clknet_4_9_0_clk_regs _0000_ VGND VGND VPWR VPWR p_ll_pipe\[0\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_47_3_Left_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_1_Right_1234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_1_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_1652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_4_3231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_940 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_add_out[16] net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_2_3538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_in1[10] net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3_3948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_lh_in1[8] net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_83_3_Right_1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_1183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_106_2_Left_920 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input63_A b[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_178_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0997__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_4_Left_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_187_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0647__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_202_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0902_ _0397_ _0402_ net187 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a21o_1
XFILLER_204_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0833_ _0339_ _0340_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_52_4_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_200_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_2_Right_1468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_925 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0764_ _0249_ net135 _0278_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a21o_1
XFILLER_227_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0695_ p_hl\[4\] net144 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_1
XFILLER_227_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1002__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_1145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0900__A2 p_lh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1152__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0557__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_2_3468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_193_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_152_3_Right_1122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_214_2683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_227_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_3_3619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_184_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_124_2_Right_1412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1101_ clknet_4_14_0_clk_regs _0122_ VGND VGND VPWR VPWR term_low\[25\] sky130_fd_sc_hd__dfxtp_1
X_1032_ clknet_4_7_0_clk_regs _0053_ VGND VGND VPWR VPWR term_high\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_219_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_2_3398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_1_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_2_3996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 b[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_4
XFILLER_176_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput62 b[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_8
XFILLER_190_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0816_ _0325_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nor2_1
Xinput51 b[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_4
XFILLER_200_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0747_ p_hl\[10\] net154 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xor2_2
XFILLER_116_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_210_3_Right_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0678_ _0204_ _0200_ net186 _0202_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__o211a_1
XFILLER_44_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_186_1_Left_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_3_3584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_972 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_213_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0574__X _0032_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_3_3549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1048__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_216_2767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_3_4049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_170_1_Left_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0749__X _0139_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input26_A a[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_116_1_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_2_4185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_2_Left_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_1654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0660__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_208_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output94_A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_201_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0601_ net186 p_hh_pipe\[27\] VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__and2_1
XFILLER_193_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_180_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_3_Left_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_4_Left_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1015_ clknet_4_6_0_clk_regs _0036_ VGND VGND VPWR VPWR term_high\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_223_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_149_4_Left_963 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0554__B p_ll\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_143_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_14_3_Right_1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_2_3543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_86_4_Left_900 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_4_3201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1088__D _0109_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0570__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_2_3508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_15_4_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_178_1_Right_1284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0569__X _0027_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_2_Right_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_211_3_Right_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0729__B _0247_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_166_2_3897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_out[12] p_hh\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_218_2818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_218_2807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_4_Left_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input29_X net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_1691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_190_3_4153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0655__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_2_3473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire171_X net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_118_1_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0549__B p_ll\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0565__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_201_2_4255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_3_3624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_200_3_Left_1397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_178_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0776__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_883 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3_4000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_144_1_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_183_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_211_3_4359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_202_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_174_2_Right_1462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_200_1_Left_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_149_3_Right_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_194_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0930__A_N p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_1_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_3_3554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_225_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_195_1_Left_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_121_3_Left_1318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0832__B p_lh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0995_ clknet_4_3_0_clk_regs _0016_ VGND VGND VPWR VPWR p_ll_pipe\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_118_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_2_Left_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_204_3_4291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_1_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[32] net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0582__X _0040_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_187_2_4116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_201_3_Left_1398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_1305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_178_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_3_Left_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hh_in1[8] net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0917__B p_lh\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xi_add_191 VGND VGND VPWR VPWR i_add_191/HI net191 sky130_fd_sc_hd__conb_1
XFILLER_2_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_1320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0652__B p_ll_pipe\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_1364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0780_ _0292_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__and2b_1
XFILLER_115_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_4_Left_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_3_Left_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_2_3513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire179_A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_158_4_Left_972 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_115_1_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0676__C1 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_ll_in2[9] net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_2_3867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_4_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_1354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_3_Left_1319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_3_Right_1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_194_1_Right_1300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0978_ net186 net156 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_203_2_Right_1491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1081__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_161_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0682__A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_184_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_add_out[15] net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_996 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_161_2_Right_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_170_3_3949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_1151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_1_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_in1[7] net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_202_3_Left_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_2_3437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_3_4310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_1_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input56_A b[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0928__A p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_90_1_Right_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input11_X net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0663__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_133_3_Right_1103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0901_ p_hl\[26\] p_lh\[26\] _0398_ _0399_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_198_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0832_ p_hl\[19\] p_lh\[19\] VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__nand2_1
XFILLER_200_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_904 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0763_ _0260_ _0265_ _0270_ _0277_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a31oi_1
XFILLER_143_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_130_4_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0694_ p_hl\[4\] net144 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__and2_1
XFILLER_115_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0838__A p_hl\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_211_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_1_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0557__B p_ll\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_181_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0573__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_220_2880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_4_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_2_3367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_218_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_214_2684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_X net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_1363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_184_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0930__B p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_158_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_3_4070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input59_X net59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1100_ clknet_4_14_0_clk_regs _0121_ VGND VGND VPWR VPWR term_low\[24\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0658__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1031_ clknet_4_7_0_clk_regs _0052_ VGND VGND VPWR VPWR term_high\[52\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_91_1_Right_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_2_Left_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_2_3297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput30 a[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_4
XFILLER_198_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput63 b[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_6
XFILLER_190_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0815_ p_hl\[17\] net148 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__and2_1
Xinput52 b[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_4
Xinput41 b[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_4
XFILLER_200_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0746_ net154 p_hl\[10\] VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__and2b_1
XFILLER_118_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_131_4_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0677_ p_hl\[1\] net147 p_hl\[0\] net155 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__o211ai_1
XFILLER_103_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_3_3585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0568__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_984 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_222_2942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0590__X _0048_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_216_2768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_4_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0750__B net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_1165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_1187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_164_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_175_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_194_2_4186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A a[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_116_1_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_2_3872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_1267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_4_Left_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_1666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_1_Right_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0600_ net186 net334 VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and2_1
XANTENNA__1142__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output87_A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire161_A p_hh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_4_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_226_3064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_162_1_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1014_ clknet_4_15_0_clk_regs _0035_ VGND VGND VPWR VPWR term_high\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_223_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_92_1_Right_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0570__B p_ll\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_2_3442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_163_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0729_ _0244_ _0247_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__nand2_1
XFILLER_104_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_2_3898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_214_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_2_3407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_out[11] p_hh\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0585__X _0043_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1015__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0745__B net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_218_2819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_2808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_210_1_Right_1316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_223_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_4_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_177_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output125_A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_190_3_4154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_3_4137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_1305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_2_3372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_23_1_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_228_3126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_228_3115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_2_4205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire164_X net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_171_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1038__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_201_2_4256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_3_3625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_1_Right_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_2_Right_1443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0581__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_178_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3_4001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_1_Left_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_4_3701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_4_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_74_2_Left_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_3_3590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input41_X net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0666__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_3_3555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_205_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_2_Right_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_3_Left_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0994_ clknet_4_12_0_clk_regs _0015_ VGND VGND VPWR VPWR p_ll_pipe\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_220_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_157_1_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hl_in2[9] net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_3_Left_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkload10_A clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_204_3_4292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0576__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_1_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_1_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_208_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[31] net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_1_Right_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_51_4_Left_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_in1[7] net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_2_3665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_192 VGND VGND VPWR VPWR i_add_192/HI net192 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_66_3_3479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_3_Right_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3_3970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_1332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_4_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_4_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_1283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0948__X _0163_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_2_3412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput6 a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_4
XFILLER_168_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[8] net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_2_3868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_2_Right_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0977_ net186 net157 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__and2_1
XFILLER_146_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_212_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_918 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[29] p_ll\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[14] net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_975 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_95_1_Right_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_lh_in1[6] net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_2_3438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_3_4311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_191_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input49_A b[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0928__B p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_1_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_130_1_Right_1236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_3_3630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0944__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0900_ p_hl\[26\] p_lh\[26\] _0397_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a21bo_1
XFILLER_221_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0831_ p_hl\[19\] p_lh\[19\] VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__and2_1
X_0762_ _0260_ _0265_ _0270_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a31o_1
XFILLER_200_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0693_ p_hl\[4\] net144 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_176_1_Left_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_97_4_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0838__B p_lh\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0854__A p_hl\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_209_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_204_1_Right_1310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_209_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0573__B p_ll\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_2_Right_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_2_3368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_960 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_160_1_Left_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_1_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_3_3560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_204_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_2_Left_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_178_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_190_3_Right_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_2_3660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0812__B1 _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_96_1_Right_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_3_3519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_182_3_4071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0939__A p_hl\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0658__B p_ll_pipe\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_4_Left_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_3_Left_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1071__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1030_ clknet_4_4_0_clk_regs _0051_ VGND VGND VPWR VPWR term_high\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_219_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_139_4_Left_953 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_222_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_198_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0814_ p_hl\[17\] net148 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_30_2_3298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput20 a[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_4
Xinput31 a[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_8
XFILLER_141_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput64 b[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_6
XFILLER_204_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput53 b[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_4
Xinput42 b[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_4
X_0745_ p_hl\[10\] net154 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and2b_1
XFILLER_190_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0676_ p_hl\[1\] net147 p_hl\[0\] net155 VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__o211a_1
XFILLER_104_908 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_4_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_996 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0584__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_3_3484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1159_ clknet_4_0_0_clk_regs _0180_ VGND VGND VPWR VPWR p_hh_pipe\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_225_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_181_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_4_Left_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_3_3449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_2_Right_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_1297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1094__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_188_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_203_3_4277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_1_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_1_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_161_2_3873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_1_Right_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_95_3_Right_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_191_3_Right_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_164_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_1_Right_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_2_4345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_201_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0669__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_226_3043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire154_A p_lh\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1013_ clknet_4_15_0_clk_regs _0034_ VGND VGND VPWR VPWR term_high\[34\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_22_1_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_195_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_2_3443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0728_ _0244_ _0247_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0579__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0659_ net186 net361 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__and2_1
XFILLER_104_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_out[10] p_hh\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_4_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_2_3408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_217_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_164_3_Right_1134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_146_2_3797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_214_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_218_2809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_1331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_3_3600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_2_Right_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_1_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_876 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input31_A a[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_3_Left_1377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output118_A net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_136_2_Right_1424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_1_Right_1286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_189_3_4138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_1_Right_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0952__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_185_1_Left_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_2_3373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_1_Right_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_2_4206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire157_X net157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_1509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_215_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_223_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_1296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0862__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_3_3524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_2_Left_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_189_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3_4002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_1_Right_1230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_1314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_220_Left_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_1_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_55_3_Left_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_4_Left_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_2_Right_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_4_Left_962 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_in2[43] term_mid\[43\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_190_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input34_X net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0947__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_181_3_Left_1378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_4_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_1_Right_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0993_ clknet_4_3_0_clk_regs _0014_ VGND VGND VPWR VPWR p_ll_pipe\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_3_3454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_1_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_99_1_Right_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hl_in2[8] net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_1655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1155__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_204_3_4293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0576__B net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_3_Right_1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_1_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[30] net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0592__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_211_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_3_Left_1340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_2_3837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[29] p_lh\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_178_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_in1[6] net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_189_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0685__B2 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_193 VGND VGND VPWR VPWR i_add_193/HI net193 sky130_fd_sc_hd__conb_1
XFILLER_215_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3_3971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1028__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_1273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_2_Right_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_2_3413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_4
XFILLER_168_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_182_3_Left_1379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_in2[7] net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_129_3_Right_1099 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_221_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_1_Right_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_140_2_3767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_903 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0976_ net186 net158 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__and2_1
XFILLER_118_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_203_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0587__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_214_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_ll_out[28] p_ll\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_191_3_4160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_639 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_i_add_out[13] net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_180_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[5] net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_144_3_Left_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_167_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_206_3_4312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_4_3596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_2_3337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_194_1_Left_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_55_2_Left_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_186_2_Right_1474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output100_A net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_187_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_4_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA__0960__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0830_ p_hl\[19\] p_lh\[19\] VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nor2_1
X_0761_ _0262_ _0267_ _0269_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o21ai_1
XFILLER_196_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire184_A net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0692_ _0214_ _0215_ _0216_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o21a_1
XFILLER_51_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1057 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0854__B p_lh\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_4_Left_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_220_2882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_1_Right_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0870__A p_hl\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0959_ net186 p_hh\[12\] VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__and2_1
XFILLER_119_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_917 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_175_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_3_Right_1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_214_2697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_152_4_Right_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_2_3267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_174_1_Right_1280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_4_Left_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_3_Left_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_4_Left_971 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_145_3_Left_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input61_A b[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_192_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_182_3_4072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0939__B p_lh\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_4_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0955__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload7_A clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0674__B net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_155_2_3842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0813_ _0309_ _0316_ _0321_ _0324_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o31a_1
Xinput21 a[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_4
Xinput10 a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
XFILLER_15_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput32 a[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_4
Xinput54 b[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_4
Xinput43 b[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_8
XFILLER_102_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0744_ p_hl\[10\] net154 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand2_1
XFILLER_116_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput65 rst VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_12
XFILLER_83_1310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0675_ _0200_ _0201_ p_hl\[0\] net155 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_116_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_1_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_2_3197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_953 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_120_1_Right_999 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_76_3_Right_1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_222_2933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_3_3485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1158_ clknet_4_12_0_clk_regs _0179_ VGND VGND VPWR VPWR p_hh_pipe\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1089_ clknet_4_8_0_clk_regs _0110_ VGND VGND VPWR VPWR term_low\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_213_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_2748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_1_Right_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_198_3_4227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_639 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_192_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_153_4_Right_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_203_3_4278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_1_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_4_3636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_1637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_141_2_3772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_1_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_1291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_210_2_4346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_146_3_Left_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input64_X net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0721__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_145_3_Right_1115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire147_A p_lh\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1012_ clknet_4_7_0_clk_regs _0033_ VGND VGND VPWR VPWR term_high\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0727_ _0228_ _0235_ _0239_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a31oi_4
XFILLER_116_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0658_ net186 p_ll_pipe\[19\] VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_39_2_3342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0589_ net186 net307 VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_179_2_4035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_1_Left_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_161_1_Right_1267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_208_1_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0595__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_4_3566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_2_3798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_2_3307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_1_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_1_Right_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1061__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_2_Left_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_154_4_Right_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_1347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_188_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input24_A a[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_217_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_189_3_4139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_3_Left_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_933 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_955 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output92_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_201_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_147_3_Left_1344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_89_3_Left_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_228_3117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_228_3106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_2_3272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1084__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_3_3525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_4_Left_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_1336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_60_3_Right_1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3_4003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3_3879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_1326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_214_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0772__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_4_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_regs_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_224_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_1_Right_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0924__B1 p_lh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_in2[42] term_mid\[42\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_4_Right_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input27_X net27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_3_3490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0963__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_205_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_220_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0992_ clknet_4_1_0_clk_regs _0013_ VGND VGND VPWR VPWR p_ll_pipe\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_220_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_3_3455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[7] net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_3_4057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_148_3_Left_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__0915__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_204_3_4294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_4_3641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_215_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_4_3606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_2_3838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[28] p_lh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in1[5] net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_189_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_189_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0685__A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_1_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_185_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_194 VGND VGND VPWR VPWR i_add_194/HI net194 sky130_fd_sc_hd__conb_1
XFILLER_109_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3_3972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_3_3379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_1_Right_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0958__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_4_Right_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_4_3571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput8 a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_4
XFILLER_168_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0676__A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[6] net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_2_3312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0975_ net186 net159 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_140_2_3768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_98_1_Left_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_175_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_150_1_Left_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_149_3_Left_1346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__0868__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_2_Right_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_out[27] p_ll\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_191_3_4161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_73_2_Left_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_933 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_add_out[12] net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_955 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[4] net27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_206_3_4313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_1_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_3_Left_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_2_3338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_129_4_Left_943 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_189_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_98_3_Left_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_3_3530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0960__B p_hh\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_187_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1145__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0760_ _0250_ _0271_ _0274_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__nor3_1
XFILLER_157_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0691_ _0215_ _0214_ net187 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21oi_1
XFILLER_109_992 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_196_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_1_Right_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire177_A net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_1_Right_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1069 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_163_3_3884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_4_Right_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_168_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_220_2872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_220_2861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_4_Left_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_209_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0870__B p_lh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0958_ net186 p_hh\[11\] VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__and2_1
XFILLER_14_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_179_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_2_3935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_929 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0889_ p_hl\[26\] p_lh\[26\] VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xor2_1
XFILLER_118_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput120 net172 VGND VGND VPWR VPWR p[59] sky130_fd_sc_hd__buf_2
XFILLER_115_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0598__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_170_2_Left_1185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_2_3268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1018__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_3_3460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_182_3_4073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_3_3419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_1_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input54_A b[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_191_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_3_Right_1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0712__A_N net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0955__B p_hh\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_206_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0971__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_4_3611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_2_3843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0812_ _0307_ _0308_ net134 _0198_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__o31a_1
Xinput22 a[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_4
Xinput11 a[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_4
XFILLER_141_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput55 b[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_4
Xinput44 b[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
Xinput33 b[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_4
X_0743_ _0254_ _0259_ _0257_ _0251_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_116_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0674_ p_hl\[1\] net147 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__nor2_1
XFILLER_115_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_2_3198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_112_932 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_170_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_158_4_Right_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_222_2945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1157_ clknet_4_12_0_clk_regs _0178_ VGND VGND VPWR VPWR p_hh_pipe\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1088_ clknet_4_8_0_clk_regs _0109_ VGND VGND VPWR VPWR term_low\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_181_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_3_3384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_216_2738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_198_3_4228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_1_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_3_3349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_171_2_Left_1186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input1_X net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_198_1_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_3_4279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_175_1_Left_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_2_3773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_157_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input57_X net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_142_1_Right_1248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_226_3056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0966__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1011_ clknet_4_7_0_clk_regs _0032_ VGND VGND VPWR VPWR term_high\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1012__D _0033_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0726_ _0194_ _0195_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__o21ai_1
XFILLER_116_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_2_Left_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0657_ net186 net331 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_39_2_3343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0588_ net186 net313 VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_179_2_4036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_4_Right_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_2_3308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0901__A2_N p_lh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2_3697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_4_Left_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_3_Left_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_159_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_138_4_Left_952 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_3_3500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_172_2_Left_1187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0786__A p_hl\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_A a[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_1_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_967 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_3_Right_1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output85_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_228_3107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_3129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_2_3273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_1303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1007__D _0028_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_191_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_2_3654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0709_ _0212_ _0220_ _0230_ _0228_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_55_3_3424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input9_A a[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3_4004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_regs_X clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_1130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_876 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_218_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0924__A1 p_hl\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_148_2_3807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_173_2_Left_1188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_224_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output123_A net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_205_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0963__B p_hh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0991_ clknet_4_2_0_clk_regs _0012_ VGND VGND VPWR VPWR p_ll_pipe\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_220_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[6] net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_3_3354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_2_Right_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_181_3_4058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_203_1_Right_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire162_X net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_211_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_135_2_Left_1150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_out[27] p_lh\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_178_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1071 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_2_3737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_184_1_Left_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in1[4] net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_189_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xi_add_195 VGND VGND VPWR VPWR i_add_195/HI net195 sky130_fd_sc_hd__conb_1
XFILLER_215_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3_3973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_2_Right_1436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0958__B p_hh\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_192_1_Right_1298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1074__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0974__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_174_2_Left_1189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XANTENNA_i_ll_in2[5] net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_2_3313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_166_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0693__B net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_91_2_Left_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_663 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1020__D _0041_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_207_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0974_ net186 net160 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and2_1
XFILLER_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_2_Right_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_212_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_3_Left_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_4_Left_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_191_3_4162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_147_4_Left_961 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[11] net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_967 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[3] net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_136_2_Left_1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_206_3_4314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_1_Right_1242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_4_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0778__B net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_120_1_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_217_Left_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_4_3496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_2_3237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_4_Left_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_9_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_187_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_226_Left_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_3_Right_1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0690_ p_hl\[2\] net146 _0211_ _0210_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0969__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0688__B net145 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_1283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3_3885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1015__D _0036_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_168_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_220_2884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold92_A p_hh_pipe\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_1363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_221_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0957_ net186 p_hh\[10\] VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and2_1
XFILLER_14_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_169_2_3936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput110 net110 VGND VGND VPWR VPWR p[4] sky130_fd_sc_hd__buf_2
XFILLER_175_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_3_Right_1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0888_ _0198_ _0389_ _0390_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_214_2688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_214_2677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput121 net121 VGND VGND VPWR VPWR p[5] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_214_2699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_149_2_3812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_2_Right_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_160_3_Right_1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_184_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_2_Left_1152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0789__A p_hl\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_182_3_4074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_1_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input47_A b[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_163_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_188_2_4125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_209_1_Left_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_206_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0971__B net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_2_Right_1420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0811_ _0321_ _0316_ _0309_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o21a_1
Xinput12 a[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_4
XFILLER_141_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0742_ _0254_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nor2_1
Xinput45 b[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_4
Xinput23 a[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_4
Xinput34 b[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_4
XFILLER_176_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput56 b[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
XFILLER_7_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0673_ p_hl\[1\] net147 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__and2_1
XFILLER_116_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_2_3742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_210_2_Left_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_1_Left_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1156_ clknet_4_2_0_clk_regs _0177_ VGND VGND VPWR VPWR p_hh_pipe\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1087_ clknet_4_10_0_clk_regs _0108_ VGND VGND VPWR VPWR term_low\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_209_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_1327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_193_1_Left_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_3_3385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_216_2739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_54_2_Left_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_198_3_4229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_1_Right_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_955 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1135__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_116_1_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_189_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_49_2_Left_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_3_Left_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_189_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_4_3536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_3_Left_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_138_2_Left_1153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_1307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_121_2_3672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_198_2_Right_1486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_226_3068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0966__B p_hh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1010_ clknet_4_5_0_clk_regs _0031_ VGND VGND VPWR VPWR p_ll_pipe\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_219_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_206_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_4_Left_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0725_ p_hl\[7\] net141 p_hl\[6\] net142 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_63_3_Left_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1008__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_156_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0656_ net186 net325 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__and2_1
XFILLER_116_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_4_Left_970 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0587_ net186 net310 VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and2_1
XANTENNA__1158__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_211_2_Left_1226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_2_3242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_187_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_3_Right_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_183_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1139_ clknet_4_2_0_clk_regs net130 VGND VGND VPWR VPWR mid_sum\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_214_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_4_3466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_4_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_3_Right_1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2_3698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_2_3207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_186_1_Right_1292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_194_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_162_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0786__B net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_191_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_194_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3_3890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_1425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_1447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_190_3_4147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_156_3_3849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_201_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_160_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_139_2_Left_1154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_228_3119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output78_A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_171_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_1315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0977__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_171_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1 mid_sum\[6\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_67_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_3_Right_1095 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_1362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_3_Right_1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0708_ p_hl\[5\] net143 _0218_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_55_3_3425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0639_ net186 net321 VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_102_1_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_1_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_1306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_181_3_Right_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_142_3_3779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_1142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_888 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0924__A2 p_lh\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_148_2_3808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_1146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output116_A net176 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_205_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0990_ clknet_4_4_0_clk_regs _0011_ VGND VGND VPWR VPWR p_ll_pipe\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_3_3390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2_3659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_1_Left_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_182_2_Right_1470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[5] net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_140_1_Left_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_157_3_Right_1127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_3_3355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1018__D _0039_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_181_3_4059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire155_X net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_195_2_4195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0990__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_63_2_Left_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_220_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_4_3541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_143_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[26] p_lh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_156_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_178_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_129_2_Right_1417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_173_1_Right_1279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_4_3506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_2_3738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_3_Left_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in1[3] net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_150_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xi_add_196 VGND VGND VPWR VPWR i_add_196/HI net196 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_88_3_Left_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3_3974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_224_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_3_3279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input32_X net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0974__B net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[4] net59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_639 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_2_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_4_3471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_4_Left_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_675 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_202_1_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_220_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_2_3212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0973_ net186 net161 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__and2_1
XFILLER_220_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_206_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_191_3_4163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_1336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[10] net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_157_3_3854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0824__A1 p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_72_3_Right_1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_in1[2] net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3_3819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_183_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_regs_X clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_202_2_4265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_2_3238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1121__D _0142_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_1_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_204_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_3_Right_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0602__X _0060_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0969__B net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_3_3430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_1273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3_4010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_1295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1172_ clknet_4_14_0_clk_regs _0193_ VGND VGND VPWR VPWR p_hh_pipe\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_168_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_220_2863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_111_2_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_220_2885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3_3784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_220_2874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_141_3_Right_1111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold85_A p_hh_pipe\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0956_ net186 p_hh\[9\] VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__and2_1
XFILLER_14_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_1_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net185 VGND VGND VPWR VPWR p[40] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_214_2689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0887_ _0374_ _0386_ _0388_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__o21ai_1
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_214_2678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput122 net171 VGND VGND VPWR VPWR p[60] sky130_fd_sc_hd__buf_2
Xoutput111 net181 VGND VGND VPWR VPWR p[50] sky130_fd_sc_hd__buf_2
XFILLER_216_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_2_3813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_201_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_3_3360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0789__B net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_3_3319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_1_Left_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_188_2_4126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0810_ _0249_ _0314_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a21oi_1
Xinput13 a[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_4
X_0741_ p_hl\[8\] net140 p_hl\[9\] net139 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a22oi_1
Xinput46 b[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_4
Xinput24 a[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_4
Xinput35 b[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_4
XFILLER_7_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 b[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_4
XFILLER_115_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_4_3511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0672_ p_hl\[0\] net155 _0199_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_72_2_Left_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_2_3743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_3_3650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1155_ clknet_4_2_0_clk_regs _0176_ VGND VGND VPWR VPWR p_hh_pipe\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_222_2936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_2925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1086_ clknet_4_10_0_clk_regs _0107_ VGND VGND VPWR VPWR term_low\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1087__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_3_Left_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_4_Left_942 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0939_ p_hl\[31\] p_lh\[31\] VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nand2_1
XFILLER_179_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_3_3284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_179_2_Right_1467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_967 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_3_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_3_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_29_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_3_3249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_216_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_216_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_189_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_212_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_121_2_3673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_1_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_3069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3_3959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_1_Right_1273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_207_3_4320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3_3824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0724_ _0243_ _0220_ _0212_ net136 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__nand4_4
XFILLER_116_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire185_X net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0655_ net186 net364 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__and2_1
XFILLER_116_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0586_ net186 net318 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__and2_1
XFILLER_6_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_2_3243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_187_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1138_ clknet_4_1_0_clk_regs _0159_ VGND VGND VPWR VPWR mid_sum\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_214_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1069_ clknet_4_4_0_clk_regs _0090_ VGND VGND VPWR VPWR term_mid\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_213_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_2_3208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1102__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_3_3400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_190_3_4148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_69_3_Right_1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_199_1_Right_1305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input62_X net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_208_2_Right_1496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_228_3109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0977__B net157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_1327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_171_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold2 mid_sum\[3\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_67_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_227_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0707_ p_hl\[4\] net144 p_hl\[5\] net143 VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o22ai_1
XFILLER_116_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_174_1_Left_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_183_3_4080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_176_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0638_ _0198_ net303 VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__and2_1
Xmax_cap187 net65 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_16
X_0569_ _0198_ p_ll\[27\] VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_102_1_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0697__A2 net145 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_3_3324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_163_2_Right_1451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_169_1_Left_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_138_3_Right_1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_1154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input22_A a[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1124__D _0145_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_128_2_3707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_2_Left_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output109_A net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_207_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1148__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[4] net59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_166_3_3910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_4_Left_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_3_Left_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_3_3254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_195_2_4196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire148_X net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_137_4_Left_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_1_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_lh_out[25] p_lh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0898__A p_hl\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_hh_in1[2] net10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_165_4_3896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_219_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_4_Left_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_197 VGND VGND VPWR VPWR i_add_197/HI net197 sky130_fd_sc_hd__conb_1
XFILLER_199_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1030__Q term_high\[51\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_224_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0601__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_130_3_Left_1327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_in2[3] net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input25_X net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_1351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_3_Right_1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_220_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0972_ net186 net162 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__and2_1
XFILLER_60_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_220_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_2_3213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_1696 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_220_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_212_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_190_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[24] p_ll\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_191_3_4164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_150_2_Right_1438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_157_3_3855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0824__A2 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[1] net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_1113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_1_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_197_2_4215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_183_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_1_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_1_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_1297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_202_2_4266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_4_3396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_204_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_208_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_196_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_131_3_Left_1328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_176_3_4011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1171_ clknet_4_9_0_clk_regs _0192_ VGND VGND VPWR VPWR p_hh_pipe\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3_3785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_183_1_Left_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_178_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0955_ net186 p_hh\[8\] VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__and2_1
XFILLER_140_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0886_ _0374_ _0386_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__or3_1
XFILLER_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput101 net184 VGND VGND VPWR VPWR p[41] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_187_1_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_2679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput123 net170 VGND VGND VPWR VPWR p[61] sky130_fd_sc_hd__buf_2
Xoutput112 net180 VGND VGND VPWR VPWR p[51] sky130_fd_sc_hd__buf_2
XFILLER_138_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_129_2_3712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_2_Left_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1090 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_190_2_Left_1205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_197_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_69_3_Left_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_13_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_192_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_90_2_Left_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1132__D net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_3_Left_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0740_ _0253_ _0257_ _0258_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o21a_1
Xinput36 b[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_4
Xinput14 a[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_4
Xinput25 a[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_21_4_Left_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput58 b[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_8
Xinput47 b[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_4
XFILLER_7_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0671_ p_hl\[0\] net155 net187 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_4_Left_960 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire175_A net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_3_Left_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1154_ clknet_4_4_0_clk_regs _0175_ VGND VGND VPWR VPWR p_hh_pipe\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_222_2937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire130_X net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_203_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1085_ clknet_4_10_0_clk_regs _0106_ VGND VGND VPWR VPWR term_low\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_4_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3_3980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0938_ p_hl\[31\] p_lh\[31\] VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__and2_1
XFILLER_179_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_4_Left_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_3_3285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0869_ p_hl\[24\] p_lh\[24\] VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__nor2_1
XFILLER_228_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_189_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1031__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_197_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_148_1_Right_1254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_191_2_Left_1206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_4_3436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_193_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1127__D _0148_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_1_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A b[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_1_Right_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_140_4_Right_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_158_3_3860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0890__B1 p_hl\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3_3825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0723_ _0233_ _0234_ _0240_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_207_3_4321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0654_ net186 net363 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__and2_1
XFILLER_171_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1037__D _0058_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire178_X net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0585_ net186 net362 VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__and2_1
XFILLER_48_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_2_4045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1054__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1137_ clknet_4_1_0_clk_regs _0158_ VGND VGND VPWR VPWR mid_sum\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_187_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1068_ clknet_4_6_0_clk_regs _0089_ VGND VGND VPWR VPWR term_mid\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_1360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_181_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_4_3366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_208_1_Left_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_190_3_4149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_delaybuf_0_clk_X clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3_3790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_78_1_Left_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_130_1_Left_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0604__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_136_3_3749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_192_2_Left_1207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input55_X net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_192_1_Left_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1077__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold3 mid_sum\[7\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_2_Left_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_144_2_Right_1432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_4_Right_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_176_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_176_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0706_ _0219_ _0224_ _0225_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o21bai_2
XFILLER_116_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_3_4081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_2_Left_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0637_ net186 net296 VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_16_3_Left_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0568_ _0198_ p_ll\[26\] VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_102_1_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_3_3325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_3_Left_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_3_3679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_198_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2_3708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input15_A a[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_1503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_160_4_3871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_4_Left_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_3_Left_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0845__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_205_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1140__D net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_207_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_209_1_Right_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[3] net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0621__X _0079_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_3_3290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_193_2_Left_1208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output83_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_166_3_3900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_1048 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0781__C1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_204_3_4287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_3_3255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_204_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_2_Right_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[24] p_lh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_4_3441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_211_2_4355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0898__B p_lh\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in1[1] net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_172_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input7_A a[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_4_3406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_34_3_Right_1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_198 VGND VGND VPWR VPWR i_add_198/HI net198 sky130_fd_sc_hd__conb_1
XFILLER_215_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_3_4100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3_3830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0601__B p_hh_pipe\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[2] net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_225_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_131_2_Right_1419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output121_A net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input18_X net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_1363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_4_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0971_ net186 net163 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__and2_1
XFILLER_220_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_908 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_1_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_4_3371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_194_2_Left_1209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_190_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire160_X net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_874 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_1305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_196_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in1[0] net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk_regs clk_regs VGND VGND VPWR VPWR clknet_0_clk_regs sky130_fd_sc_hd__clkbuf_16
XFILLER_220_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_2_Right_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3_3754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_197_2_4216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_3_3719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_87_1_Left_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1041__Q term_high\[62\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0612__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_985 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_2_Left_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_2_Right_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3_4012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ clknet_4_14_0_clk_regs _0191_ VGND VGND VPWR VPWR p_hh_pipe\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_3_3330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_1_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_2990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_194_2_Right_1482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_220_2887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_220_2876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_3_Left_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_178_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0954_ net186 p_hh\[7\] VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__and2_1
XFILLER_119_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_123_3_3684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_2_3945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0885_ p_hl\[25\] p_lh\[25\] VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_213_Left_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput102 net183 VGND VGND VPWR VPWR p[42] sky130_fd_sc_hd__buf_2
XFILLER_115_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput124 net169 VGND VGND VPWR VPWR p[62] sky130_fd_sc_hd__buf_2
Xoutput113 net179 VGND VGND VPWR VPWR p[52] sky130_fd_sc_hd__buf_2
XFILLER_216_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_190_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_222_Left_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_129_2_3713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_217_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2_3661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_10_0_clk_regs_X clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_184_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_226_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_2_Right_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_194_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_156_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0733__A2 _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1036__Q term_high\[57\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_3_3260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_1663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0607__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_3_3219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 b[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_4
XFILLER_168_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 a[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_4
Xinput26 a[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_4
XFILLER_7_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput59 b[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_8
XFILLER_204_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0670_ net186 net357 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__and2_1
XFILLER_183_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 b[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_4
XFILLER_7_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_4_3411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire168_A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_2_Right_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_222_2949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1153_ clknet_4_4_0_clk_regs _0174_ VGND VGND VPWR VPWR p_hh_pipe\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_222_2938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1084_ clknet_4_10_0_clk_regs _0105_ VGND VGND VPWR VPWR term_low\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_129_1_Right_1235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_209_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3_3981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_221_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0937_ p_hl\[31\] p_lh\[31\] VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nor2_1
XFILLER_101_1139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_228_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0868_ _0198_ _0371_ _0372_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__and3_1
XFILLER_174_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0799_ _0284_ _0290_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
XFILLER_228_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_216_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_121_3_Right_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_980 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_3_Right_1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_186_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_205_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_201_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_197_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_A b[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_226_3049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_1357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_181_2_Right_1469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_192_3_4170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0890__A1 p_hl\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0890__B2 p_lh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_176_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0722_ _0239_ _0241_ _0242_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__o21a_1
XFILLER_156_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_207_3_4322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0653_ net186 p_ll_pipe\[14\] VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and2_1
XFILLER_217_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0584_ net186 net355 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__and2_1
XFILLER_171_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_2_4046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3_3724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_2_Right_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_153_3_Right_1123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0993__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1136_ clknet_4_5_0_clk_regs _0157_ VGND VGND VPWR VPWR mid_sum\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1067_ clknet_4_6_0_clk_regs _0088_ VGND VGND VPWR VPWR term_mid\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_224_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_1_Left_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_1_Left_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_194_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_1332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_2_Right_1413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1076 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_2_Left_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_3_3300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0620__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input48_X net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_3_Left_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold4 mid_sum\[4\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0619__X _0077_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_4_Left_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0705_ net186 _0226_ _0227_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__and3_1
XFILLER_117_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_209_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_183_3_4082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1021__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0636_ net186 net350 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and2_1
XFILLER_154_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0567_ _0198_ p_ll\[25\] VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_102_1_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_59_4_Left_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_2_Right_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_210_2_Right_1498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_183_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1119_ clknet_4_0_0_clk_regs _0140_ VGND VGND VPWR VPWR mid_sum\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_214_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_3_3224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0705__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_2_Left_1136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_1_Right_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_4_3866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0615__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[2] net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1044__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3_3901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output76_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_3_Right_1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_204_3_4288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_179_1_Right_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_15_0_clk_regs_X clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[23] p_lh\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_160_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_211_2_4356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0619_ net186 net343 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and2_1
XANTENNA_i_hh_in1[0] net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_2_Right_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_1_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_4_3796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_add_188 VGND VGND VPWR VPWR i_add_188/HI net188 sky130_fd_sc_hd__conb_1
Xi_add_199 VGND VGND VPWR VPWR i_add_199/HI net199 sky130_fd_sc_hd__conb_1
XFILLER_214_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_3_4101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1067__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_190_3_Left_1387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_210_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_1_Right_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_2_Left_1137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_in2[1] net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_173_1_Left_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output114_A net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0990__D _0011_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_207_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0970_ net186 net164 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__and2_1
XFILLER_198_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0632__X _0090_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_212_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_168_1_Left_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire153_X net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_2_3577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_2_Left_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_188_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_3_3755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0702__B net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_206_3_4307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_2_Left_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_175_2_Right_1463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_167_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_45_2_Right_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_204_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_4_3296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_4_Left_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_191_3_Left_1388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_3_Left_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_4_Left_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[29] p_hl\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_2_Left_1138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_1_Right_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1146__D _0167_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input30_X net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_176_3_4013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_224_2991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_186_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0953_ _0198_ p_hh\[6\] VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__and2_1
XFILLER_220_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_4_Left_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_123_3_3685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_2_3946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0884_ _0386_ _0387_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__nor2_1
XFILLER_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput103 net182 VGND VGND VPWR VPWR p[43] sky130_fd_sc_hd__buf_2
XFILLER_115_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_1_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput125 net168 VGND VGND VPWR VPWR p[63] sky130_fd_sc_hd__buf_2
Xoutput114 net178 VGND VGND VPWR VPWR p[53] sky130_fd_sc_hd__buf_2
XFILLER_114_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1056__D _0077_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_153_3_Left_1350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_1338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_1_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_4_3836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_219_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_182_3_4067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_46_2_Right_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_204_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0623__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput16 a[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_8
Xinput27 a[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_4
XFILLER_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_192_3_Left_1389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput38 b[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_4
XFILLER_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 b[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_4
XFILLER_7_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_1_Right_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_3_Right_1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_124_2_Left_1139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_229_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_195_1_Right_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_2_3666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_981 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_204_2_Right_1492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_970 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1152_ clknet_4_4_0_clk_regs _0173_ VGND VGND VPWR VPWR p_hh_pipe\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_222_2939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1083_ clknet_4_11_0_clk_regs _0104_ VGND VGND VPWR VPWR term_low\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_203_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_1309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_3617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_3_3982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_179_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0936_ _0431_ _0433_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nor2_1
XFILLER_105_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0867_ _0361_ _0367_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a21bo_1
XFILLER_228_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0798_ _0292_ _0293_ _0300_ _0302_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__nand4b_1
XFILLER_216_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_948 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_937 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_154_3_Left_1351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_227_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_200_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_120_1_Left_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_205_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_197_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_134_3_Right_1104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_182_1_Left_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_4_3336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input38_A b[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_2_3582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_3_4171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0618__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_210_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0890__A2 p_lh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_2_3547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_215_2721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3_3760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0721_ _0241_ _0239_ net187 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a21oi_1
XFILLER_7_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0640__X _0098_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_207_3_4323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire180_A net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0652_ net186 p_ll_pipe\[13\] VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_38_2_Left_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0583_ net186 net358 VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and2_1
XFILLER_87_1282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_150_1_Right_1256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3_3725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_1_Right_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_68_3_Left_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1135_ clknet_4_3_0_clk_regs net132 VGND VGND VPWR VPWR mid_sum\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_4_Right_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1066_ clknet_4_15_0_clk_regs _0087_ VGND VGND VPWR VPWR term_mid\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_1286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold86_X net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_181_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_194_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0919_ _0417_ _0416_ net187 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0710__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_4_3266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_3_Left_1352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_3_Left_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_1667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_4_Left_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_1088 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_216_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_3_3690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_1209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold5 mid_sum\[5\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_181_1_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_208_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_4_Left_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkload3_A clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0635__X _0093_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_2_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_2_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_154_4_3841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0704_ _0219_ _0223_ _0224_ _0225_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a211o_1
XFILLER_144_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_3_4083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire183_X net183 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_176_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0635_ _0198_ net317 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__and2_1
XFILLER_154_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0566_ _0198_ p_ll\[24\] VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_102_1_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_1_Right_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_1320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1118_ clknet_4_2_0_clk_regs _0139_ VGND VGND VPWR VPWR mid_sum\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_81_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_163_4_Right_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1049_ clknet_4_9_0_clk_regs _0070_ VGND VGND VPWR VPWR term_mid\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_3_3225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1076 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_892 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_3_Left_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_1215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_1538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_71_4_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_2_3622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_140_4_3771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[1] net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_199_3_4238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0631__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input60_X net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_166_3_3902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_214_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output69_A net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_146_3_3800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_204_3_4289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire143_A p_lh\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_1_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_207_1_Left_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_211_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[22] p_lh\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_160_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0541__A net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_4_3341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0618_ net186 net346 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_211_1_Right_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0549_ net186 p_ll\[7\] VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_77_1_Left_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_1_Right_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_1_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_189 VGND VGND VPWR VPWR i_add_189/HI net189 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_31_4_3306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_2_3552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_191_1_Left_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_164_4_Right_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_197_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_3_4102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_3_3967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_2_Left_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_132_3_3730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_in2[0] net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input20_A a[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_166_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_157_3_Left_1354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_1294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0626__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_2_Left_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_3_Left_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output107_A net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_176_1_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_1644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1011__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_201_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1161__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_177_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_173_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_4_3271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_156_2_Right_1444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_2_3578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire146_X net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_188_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_3_Left_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_206_3_4308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_1_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_1_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_189_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0929__A_N p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_1_Right_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1034__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_214_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_165_4_Right_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_204_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[28] p_hl\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_144_1_Right_1250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_211_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3_4014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_X net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_158_3_Left_1355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_224_2992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_209_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_3_3230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0643__X _0101_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0952_ _0198_ p_hh\[5\] VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__and2_2
XFILLER_186_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0883_ _0375_ _0379_ _0383_ net187 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a31o_1
XFILLER_220_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 net104 VGND VGND VPWR VPWR p[44] sky130_fd_sc_hd__buf_2
XFILLER_114_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput115 net177 VGND VGND VPWR VPWR p[54] sky130_fd_sc_hd__buf_2
Xoutput126 net126 VGND VGND VPWR VPWR p[6] sky130_fd_sc_hd__buf_2
XFILLER_216_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1057__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1072__D _0093_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_184_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0553__X _0011_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_1_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_194_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_46_3_Right_1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_3_4068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_4_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_156_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_15_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_219_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_1_Right_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0904__A p_hl\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[49] net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput17 a[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_4
Xinput28 a[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_4
XFILLER_221_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput39 b[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_183_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_178_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1151_ clknet_4_4_0_clk_regs _0172_ VGND VGND VPWR VPWR p_hh_pipe\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_222_2929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1082_ clknet_4_10_0_clk_regs _0103_ VGND VGND VPWR VPWR term_low\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_4_3311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_225_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_149_1_Left_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_159_3_Left_1356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_2_3618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_3_3983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0814__A p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_1_Left_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_1233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0935_ _0421_ _0423_ _0428_ _0430_ net187 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a41o_1
XFILLER_200_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0866_ _0368_ _0369_ _0361_ _0367_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__o211ai_1
XFILLER_119_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0774__A_N net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_196_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1067__D _0088_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0797_ _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__nor2_1
XFILLER_216_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_1215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0992__Q p_ll_pipe\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_2_Left_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_1265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_1_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_131_1_Right_1237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0730__Y _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_3_Left_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1063__Q term_mid\[36\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_2_3583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_3_4172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_223_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_1_Right_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_2_3548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_215_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0634__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0720_ _0231_ _0235_ _0232_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_215_2722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_207_3_4324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output99_A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0651_ net186 net360 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__and2_1
XFILLER_7_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0582_ net186 net324 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_205_1_Right_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire173_A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_174_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_4_Left_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1134_ clknet_4_1_0_clk_regs _0155_ VGND VGND VPWR VPWR mid_sum\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_93_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1065_ clknet_4_6_0_clk_regs _0086_ VGND VGND VPWR VPWR term_mid\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_180_2_Left_1195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0544__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_194_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0918_ _0414_ _0406_ _0405_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21o_1
XFILLER_107_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0849_ net138 _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor2_1
XFILLER_153_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_225_3040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_1679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_3_Right_1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_3_3200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_A b[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_175_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_add_in1[63] term_high\[63\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1118__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold6 mid_sum\[1\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__0629__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_1_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0916__X _0157_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_200_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0651__X _0109_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_1258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0703_ _0224_ _0225_ _0217_ _0221_ _0219_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o221ai_1
XFILLER_15_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_3_4084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0634_ net186 net300 VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__and2_1
XFILLER_193_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire176_X net176 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0565_ _0198_ p_ll\[23\] VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_102_1_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_154_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_1332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0539__A p_hl\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1117_ clknet_4_13_0_clk_regs _0138_ VGND VGND VPWR VPWR mid_sum\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_227_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1080__D _0101_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1022 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1048_ clknet_4_8_0_clk_regs _0069_ VGND VGND VPWR VPWR term_mid\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_189_2_4135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1088 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_181_2_Left_1196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_202_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_194_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_3_Right_1086 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_227_3102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_150_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_1107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_1205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_1227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_164_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_158_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_2_3623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_139_4_3766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hl_in2[0] net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_3_4239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3_3903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0781__A2 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input53_X net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_158_1_Left_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_95_1_Left_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_19_2_Left_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1090__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0646__X _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_223_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[21] p_lh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_165_3_Right_1135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_70_2_Left_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0617_ net186 net337 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__and2_1
XFILLER_63_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0548_ net186 p_ll\[6\] VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__and2_1
XFILLER_217_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_2_3553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_125_4_3696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_182_2_Left_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_185_3_4103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_3_3968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_3_Left_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_126_4_Left_940 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_2_Right_1425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_181_1_Right_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_198_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_1_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_1_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_162_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[28] p_hh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_A a[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_207_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_166_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_214_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_198_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_220_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_4_Left_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0642__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_187_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_1304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output81_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_177_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_212_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0911__C1 p_lh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_188_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_191_3_4157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire139_X net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_184_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_2_3477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_184_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0552__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_125_1_Right_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_195_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_206_3_4309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0995__Q p_ll_pipe\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_A a[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_3_Right_1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_183_2_Left_1198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_161_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_hl_out[27] p_hl\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_210_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_4_3806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0637__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_206_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input16_X net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_224_2993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_2_Right_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_224_2982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_2868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0951_ _0198_ p_hh\[4\] VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_27_3_Right_1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0882_ _0379_ _0383_ _0375_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a21oi_1
XANTENNA_clkbuf_4_0_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput105 net105 VGND VGND VPWR VPWR p[45] sky130_fd_sc_hd__buf_2
XFILLER_103_1172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput116 net176 VGND VGND VPWR VPWR p[55] sky130_fd_sc_hd__buf_2
XFILLER_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput127 net127 VGND VGND VPWR VPWR p[7] sky130_fd_sc_hd__buf_2
XFILLER_114_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_145_2_Left_1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0547__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_110_1_Left_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_172_1_Left_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_3_4069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_4_3736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_1685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1001__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input8_X net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1151__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_129_1_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_160_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_226_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_167_1_Left_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_204_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0904__B p_lh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[9] net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_add_out[48] net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_184_2_Left_1199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_183_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 a[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_4
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput29 a[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_28_2_Left_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_213_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_183_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_213_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1150_ clknet_4_4_0_clk_regs _0171_ VGND VGND VPWR VPWR p_hh_pipe\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_222_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1081_ clknet_4_11_0_clk_regs _0102_ VGND VGND VPWR VPWR term_low\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_2_Right_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_185_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0654__X _0112_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_173_3_3984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0814__B net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0934_ _0427_ _0429_ _0424_ _0420_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o22ai_1
XFILLER_105_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0865_ _0368_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__nor2_1
XANTENNA__0830__A p_hl\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_2_3517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0796_ p_hl\[16\] p_lh\[16\] VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__and2_1
XFILLER_196_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1083__D _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_2_Left_1161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0829__X _0147_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_4_Left_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_1205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_3_Left_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_2_Right_1475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_1649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_4_Left_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_4_3236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_192_3_4173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_2_3482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_222_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_2_3447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0650__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0650_ net186 net345 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__and2_2
XFILLER_171_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0581_ net186 net372 VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__and2_1
XFILLER_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0649__X _0107_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire166_A p_hh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1133_ clknet_4_1_0_clk_regs _0154_ VGND VGND VPWR VPWR mid_sum\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_226_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_203_2_4275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1064_ clknet_4_13_0_clk_regs _0085_ VGND VGND VPWR VPWR term_mid\[37\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_11_3_Right_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_115_2_Left_929 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_1307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_2_Right_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0544__B p_ll\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_194_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_163_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1078__D _0099_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0917_ p_hl\[29\] p_lh\[29\] VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__xor2_1
XFILLER_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_175_1_Right_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0560__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_147_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0848_ p_hl\[21\] p_lh\[21\] VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__and2_1
XFILLER_115_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0779_ p_hl\[14\] net150 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_148_4_3811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_192_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_225_3041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3_4020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_147_2_Left_1162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0857__A1 p_hl\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_4_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0793__B1 _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input43_A b[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in1[62] term_high\[62\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 mid_sum\[0\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_169_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0645__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_3_Right_1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_1272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_1215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0702_ p_hl\[5\] net143 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__and2_1
XFILLER_117_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0784__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0633_ net186 net291 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__and2_1
Xmax_cap137 _0391_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_134_4_3741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_152_1_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire169_X net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0564_ _0198_ p_ll\[22\] VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__and2_1
XFILLER_152_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1116_ clknet_4_12_0_clk_regs _0137_ VGND VGND VPWR VPWR mid_sum\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_81_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_226_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1047_ clknet_4_9_0_clk_regs _0068_ VGND VGND VPWR VPWR term_mid\[20\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0555__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_189_2_4136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_181_1_Left_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_1361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1159__Q p_hh_pipe\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0998__Q p_ll_pipe\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_3_3589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_2_Left_1163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_2_Left_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_4_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_164_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_3_Right_1116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1069__Q term_mid\[42\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_229_Left_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_5_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_106_1_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_2_3522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_192_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_1650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_X net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_1_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3_3700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_out[20] p_lh\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_1_Right_1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_3_Left_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0616_ net186 net305 VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__and2_1
XFILLER_217_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload15_A clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0547_ net186 p_ll\[5\] VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__and2_1
XFILLER_213_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1091__D _0112_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_4_3241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_185_3_4104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_4_3206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3_3969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_2_3452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_4_Left_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_208_3_4330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_1145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0748__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_4_Left_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_149_2_Left_1164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_4_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_179_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0739__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_212_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output74_A net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_209_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0911__B1 p_hl\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0657__X _0115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1051 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_147_1_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_184_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_191_3_4158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_3_Right_1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_224_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_1581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_load_slew186_X net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_2_3478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_1232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_189_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_1243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0552__B p_ll\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_4_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1086__D _0107_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0902__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_3_3629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_in2[15] net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_157_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hl_out[26] p_hl\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_174_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_2_3655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1080__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_184_3_4090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_206_1_Left_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in2[9] net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_130_3_Right_1100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_139_1_Left_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_224_2983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_209_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_220_2869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output112_A net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0672__A2 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0653__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0950_ _0198_ p_hh\[3\] VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_76_1_Left_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0881_ _0377_ net134 _0383_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__o21a_1
XFILLER_9_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput106 net106 VGND VGND VPWR VPWR p[46] sky130_fd_sc_hd__buf_2
Xoutput128 net128 VGND VGND VPWR VPWR p[8] sky130_fd_sc_hd__buf_2
Xoutput117 net175 VGND VGND VPWR VPWR p[56] sky130_fd_sc_hd__buf_2
XFILLER_142_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_3_3594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire151_X net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_2_Left_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0547__B p_ll\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_3_3559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0563__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_1_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_167_3_3920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_1333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_2_Left_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_195_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_3_Left_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_1304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[47] net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_i_lh_in2[8] net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_183_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 a[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_4
XFILLER_168_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_1324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_213_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_120_2_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_4_Left_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0648__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1080_ clknet_4_11_0_clk_regs _0101_ VGND VGND VPWR VPWR term_low\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_3_Left_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_4_3211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_168_2_Right_1456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0933_ _0428_ _0430_ _0421_ _0423_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a22oi_2
XANTENNA__0670__X _0128_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0864_ p_hl\[23\] p_lh\[23\] VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__and2_1
XFILLER_220_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0830__B p_lh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_2_3518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0795_ p_hl\[16\] p_lh\[16\] VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nor2_1
XFILLER_192_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0558__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_995 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0580__X _0038_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_165_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_1_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_962 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_221_2920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_3_4174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_2_3483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_182_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_1_Right_1262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_2_3448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_198_2_4225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0580_ net186 p_hh_pipe\[6\] VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__and2_1
XFILLER_139_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire159_A p_hh\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1132_ clknet_4_5_0_clk_regs net133 VGND VGND VPWR VPWR mid_sum\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_203_2_4276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_3_3634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1063_ clknet_4_15_0_clk_regs _0084_ VGND VGND VPWR VPWR term_mid\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_185_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_1319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0916_ _0406_ _0408_ _0412_ _0415_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__o31a_2
XFILLER_105_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0560__B p_ll\[18\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_162_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0847_ p_hl\[21\] p_lh\[21\] VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__nor2_1
XFILLER_66_1314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1141__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0778_ p_hl\[14\] net150 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__nor2_1
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1094__D _0115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_1672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3_4021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0857__A2 p_lh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0575__X _0033_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0735__B net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_3_Right_1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_205_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_1_Left_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_175_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in1[61] term_high\[61\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_85_1_Left_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 mid_sum\[19\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input36_A b[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_212_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_3_3564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_208_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1014__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1164__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0661__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_1284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0701_ p_hl\[5\] net143 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nor2_1
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_2_Left_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0632_ _0198_ net320 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__and2_1
Xmax_cap138 _0354_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_1
XFILLER_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0563_ _0198_ p_ll\[21\] VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__and2_1
XFILLER_112_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_1_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1115_ clknet_4_13_0_clk_regs _0136_ VGND VGND VPWR VPWR mid_sum\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_152_2_Right_1440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1046_ clknet_4_11_0_clk_regs _0067_ VGND VGND VPWR VPWR term_mid\[19\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0555__B p_ll\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_3_Left_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1089__D _0110_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_202_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0571__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1037__CLK clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_1_Right_1249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_213_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_48_4_Left_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_174_3_3990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_164_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_2_0_clk_regs_X clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_199_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_181_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_2_3523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_166_3_3905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in1[44] term_high\[44\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input39_X net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_212_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0656__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_162_2_3877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkload1_A clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_211_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire180 net112 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_4
XFILLER_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire181_X net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0615_ net186 net312 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and2_1
XFILLER_217_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0546_ net186 p_ll\[4\] VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__and2_1
XFILLER_63_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0566__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1029_ clknet_4_1_0_clk_regs _0050_ VGND VGND VPWR VPWR term_high\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_210_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_2_3453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_208_3_4331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_2_4055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_3_Right_1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_1_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_1_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_i_lh_in2[15] net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[26] p_hh\[26\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_183_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_3_3604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_201_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output67_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0911__A1 p_hl\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire141_A p_lh\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_191_3_4159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_1_Left_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_229_1593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_2_3377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0583__X _0041_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_1_Left_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[63] net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_1298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[14] net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_94_1_Left_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[25] p_hl\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_18_2_Left_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_184_3_4091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_202_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_in2[8] net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_100_3_Left_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_4_3706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_2984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output105_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_198_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0653__B p_ll_pipe\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0880_ _0376_ _0350_ _0382_ _0381_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__o211ai_1
XFILLER_9_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_218_2799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR p[47] sky130_fd_sc_hd__buf_2
XFILLER_103_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput129 net129 VGND VGND VPWR VPWR p[9] sky130_fd_sc_hd__buf_2
Xoutput118 net174 VGND VGND VPWR VPWR p[57] sky130_fd_sc_hd__buf_2
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_3_3595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_3_Left_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire144_X net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_177_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_1356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0578__X _0036_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_4_Left_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_205_3_4297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_219_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_1291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_163_2_3882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_227_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_140_3_Left_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_149_2_Right_1437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_193_1_Right_1299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[46] net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[7] net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_183_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_1336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_213_2663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_174_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_982 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_X net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_105_2_Left_919 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0664__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_186_3_4110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_1282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0951__X _0166_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0932_ p_lh\[30\] p_hl\[30\] VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0863_ p_hl\[23\] p_lh\[23\] VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nor2_1
XFILLER_220_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_rst net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0794_ _0304_ _0305_ _0306_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a21oi_2
XFILLER_6_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_2_3417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_1354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0558__B p_ll\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_4_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_1_Right_1243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1070__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0574__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_1_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_7_0_clk_regs_X clknet_4_7_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_165_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_1661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_203_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_1118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_1_3196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_974 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_3_Right_1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_188_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_3_Left_1338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_109_1_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_2_3382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_215_2736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[29] net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_215_2725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0931__B p_hl\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_215_2714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_198_2_4226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_171_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_2_3347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0659__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1093__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1131_ clknet_4_1_0_clk_regs _0152_ VGND VGND VPWR VPWR mid_sum\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_225_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_1251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1062_ clknet_4_15_0_clk_regs _0083_ VGND VGND VPWR VPWR term_mid\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_3_Right_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_171_1_Left_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_3_3635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_14_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_226_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_175_1_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0915_ _0414_ _0406_ net187 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0846_ _0347_ _0352_ _0353_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__o21a_1
XFILLER_196_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0777_ _0286_ _0290_ _0291_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o21a_1
XFILLER_192_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1017 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0569__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_166_1_Left_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_229_3190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_1684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_177_3_4022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_161_3_Right_1131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_4_3711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_2_Left_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_207_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_185_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0591__X _0049_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0751__B net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_149_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_2_3955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_175_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_175_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_133_2_Right_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 mid_sum\[27\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input29_A a[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_3_3565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_142_3_Left_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_3_Left_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0700_ net186 _0222_ _0223_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__and3_1
XFILLER_209_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output97_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0631_ _0198_ net339 VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__and2_2
XFILLER_144_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0562_ _0198_ p_ll\[20\] VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__and2_1
XFILLER_217_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire171_A net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1114_ clknet_4_14_0_clk_regs _0135_ VGND VGND VPWR VPWR mid_sum\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1045_ clknet_4_8_0_clk_regs _0066_ VGND VGND VPWR VPWR term_mid\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_228_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_202_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0571__B p_ll\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_4_Left_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0829_ _0332_ _0336_ _0338_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o21a_1
XFILLER_107_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_1_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_3_3489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_226_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_199_2_Right_1487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_174_3_3991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3_3906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_150_4_Right_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_114_2_Left_928 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_2_3422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_192_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0937__A p_hl\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0656__B net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_2_3878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_4_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire181 net111 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_8
Xwire170 net123 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_6
XFILLER_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0614_ net186 net315 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and2_1
XFILLER_217_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire174_X net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_3_Right_1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0545_ net186 p_ll\[3\] VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__and2_1
XFILLER_217_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0999__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0847__A p_hl\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xload_slew186 _0198_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_12
XFILLER_39_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0566__B p_ll\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_1_Right_1293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1028_ clknet_4_4_0_clk_regs _0049_ VGND VGND VPWR VPWR term_high\[49\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0853__Y _0150_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_228_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0582__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_202_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_208_3_4332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1004__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_2_3352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_2_4056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_218_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[14] net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1154__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_hh_out[25] p_hh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_129_1_Left_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_3_3640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0684__B2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_639 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_3_3605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_201_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_151_4_Right_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input51_X net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0667__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0911__A2 p_lh\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_126_3_Right_1096 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_3_Right_1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0675__B2 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_1_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_2_3378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1027__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_2_Left_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_1295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0577__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_3_3570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_227_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_i_add_out[62] net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_3_3529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_ll_in2[13] net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_143_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_hl_out[24] p_hl\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_178_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_184_3_4092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_4_Left_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_183_2_Right_1471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[7] net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_176_3_4007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_3_Left_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_158_3_Right_1128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_224_2996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input11_A a[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_224_2985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_200_3_4250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_209_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0950__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net108 VGND VGND VPWR VPWR p[48] sky130_fd_sc_hd__buf_2
XFILLER_177_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput119 net173 VGND VGND VPWR VPWR p[58] sky130_fd_sc_hd__buf_2
XFILLER_217_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_2_Right_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput90 net90 VGND VGND VPWR VPWR p[31] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_69_3_3494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_225_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1020 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_3_3459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_4_Left_908 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_203_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_972 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_1035 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A a[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_205_3_4298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_2_3883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_180_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_193_1_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[45] net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[6] net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_in3[30] term_low\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_174_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input59_A b[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_219_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_994 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0929__B p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0767__A_N net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input14_X net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_1294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0931_ p_lh\[30\] p_hl\[30\] VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__and2b_1
XFILLER_14_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0862_ _0198_ _0366_ _0367_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__and3_1
XFILLER_9_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0793_ _0304_ _0305_ _0198_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__o21ai_1
XFILLER_9_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_3_Right_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_2_Right_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_2_3418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0855__A p_hl\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_205_1_Left_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_3_3610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0590__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_1_Left_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_170_2_Right_1458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_1_Left_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input6_X net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_221_2911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_188_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_2_Right_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_179_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_219_2851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_2_3383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_1_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[28] net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_215_2726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_2_Left_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_215_2715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_207_3_4317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_1292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_1_Right_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_142_3_Right_1112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_2_3348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1130_ clknet_4_0_0_clk_regs _0151_ VGND VGND VPWR VPWR mid_sum\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_93_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1061_ clknet_4_15_0_clk_regs _0082_ VGND VGND VPWR VPWR term_mid\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_2_Left_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_3_Left_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_3_3534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0914_ _0407_ _0385_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0845_ _0352_ _0347_ net187 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0932__A_N p_lh\[30\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0776_ _0286_ _0290_ net187 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__a21oi_1
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0569__B p_ll\[27\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3_4023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_2_Right_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_229_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_14_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0585__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_225_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_4_Left_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_171_2_3956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_1_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_186_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_182_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_2_Right_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_3_3464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_1327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0769__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_209_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0630_ net186 net354 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__and2_1
XFILLER_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_3_4077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0561_ _0198_ p_ll\[19\] VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__and2_1
XFILLER_152_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1113_ clknet_4_14_0_clk_regs _0134_ VGND VGND VPWR VPWR mid_sum\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_130_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1044_ clknet_4_8_0_clk_regs _0065_ VGND VGND VPWR VPWR term_mid\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_190_2_4145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_1331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_156_2_3847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xi_lh VGND VPWR clknet_1_1__leaf_clk net1 net2 net3 net4 net5 net6 net7 net12 net23
+ net26 net27 net28 net29 net30 net31 net32 net40 net51 net52 net53 net54 net56 net57
+ net41 net42 net43 net45 net46 net47 net48 net49 net50 p_lh\[0\] p_lh\[10\] p_lh\[11\]
+ p_lh\[12\] p_lh\[13\] p_lh\[14\] p_lh\[15\] p_lh\[16\] p_lh\[17\] p_lh\[18\] p_lh\[19\]
+ p_lh\[1\] p_lh\[20\] p_lh\[21\] p_lh\[22\] p_lh\[23\] p_lh\[24\] p_lh\[25\] p_lh\[26\]
+ p_lh\[27\] p_lh\[28\] p_lh\[29\] p_lh\[2\] p_lh\[30\] p_lh\[31\] p_lh\[3\] p_lh\[4\]
+ p_lh\[5\] p_lh\[6\] p_lh\[7\] p_lh\[8\] p_lh\[9\] net65 mult_16x16
XFILLER_198_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0828_ _0336_ _0332_ net187 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0759_ _0263_ _0264_ _0270_ _0257_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__o211ai_1
XFILLER_157_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3_3992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1083__CLK clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_181_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_166_3_3907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_1_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_2_3423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input41_A b[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0777__X _0142_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__0937__B p_lh\[31\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_168_1_Right_1274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output128_A net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_223_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0953__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_182_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_2_3777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_2_Right_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire182 net103 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_4
XFILLER_102_1059 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire171 net122 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_6
Xwire160 p_hh\[27\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_4
XFILLER_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_216_Left_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0613_ net186 net285 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__and2_1
XFILLER_193_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0544_ net186 p_ll\[2\] VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__and2_1
XFILLER_217_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_wire167_X net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0847__B p_lh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_130_2_Left_1145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_225_Left_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_193_3_4181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_147_1_Left_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1027_ clknet_4_4_0_clk_regs _0048_ VGND VGND VPWR VPWR term_high\[48\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__0863__A p_hl\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_210_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_84_1_Left_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_208_3_4333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_229_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1011 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_2_3353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[13] net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_hh_out[24] p_hh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_209_2_Right_1497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0684__A2 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_169_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_187_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_3_3504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_3_Left_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_206_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_1330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input44_X net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0948__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_209_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold90 p_hh_pipe\[7\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_110_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_2_Right_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_2_3277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_164_2_Right_1452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_4_Left_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_139_3_Right_1109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0577__B net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_40_1_Right_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_131_2_Left_1146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0593__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[61] net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_228_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_in2[12] net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_206_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[23] p_hl\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_195_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_202_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_184_3_4093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_3_4200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1121__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_in2[6] net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_176_3_4008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_206_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_224_2986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_200_3_4251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_214_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_2_3852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net109 VGND VGND VPWR VPWR p[49] sky130_fd_sc_hd__buf_2
XFILLER_177_1277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_981 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_217_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_2_3817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output72_A net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput80 net80 VGND VGND VPWR VPWR p[22] sky130_fd_sc_hd__buf_2
XFILLER_190_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput91 net91 VGND VGND VPWR VPWR p[32] sky130_fd_sc_hd__buf_2
XFILLER_214_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_4_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_3_3495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0965__X _0180_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_2_Right_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_195_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_107_1_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_907 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1144__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0588__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_205_3_4299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_4_3646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_1_Right_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_2_Left_1147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_143_2_3782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[44] net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[5] net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_217_2790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_1316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_183_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_3_Right_1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_213_2665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_213_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_965 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_219_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_976 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0785__X _0143_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1017__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output110_A net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_3_3977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0961__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_159_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0930_ p_hl\[30\] p_lh\[30\] VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2b_1
XFILLER_14_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_1374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_200_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_179_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0680__B net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0861_ _0365_ _0362_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__nand2_1
XFILLER_174_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0792_ _0297_ _0294_ _0293_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a21boi_1
XFILLER_228_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_151_2_Right_1439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_1_Left_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_190_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_932 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_910 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_4_3576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_93_1_Left_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_2_Left_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_2_3317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0855__B p_lh\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_2_Right_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_1366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_221_2912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0765__B net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_227_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_42_1_Right_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_1276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_2_Left_1148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_219_2852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_3_Left_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_219_2841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[27] net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_215_2727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_207_3_4318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_2_3282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0956__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_2_Right_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_2_3247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ clknet_4_5_0_clk_regs _0081_ VGND VGND VPWR VPWR term_mid\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_1231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_163_3_Left_1360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_3_3535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_163_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_4_Left_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0913_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__inv_2
XFILLER_119_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0844_ _0351_ net134 _0350_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__o21ai_2
XFILLER_204_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0775_ _0288_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nand2_2
XANTENNA_clkbuf_4_11_0_clk_regs_X clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_192_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_192_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_229_3181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3_4024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3_3889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1006 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_104_2_Left_918 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_2_Right_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_151_2_3822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_1_Right_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2_3662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_134_2_Left_1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_3_3465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_4_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_183_3_4078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0560_ _0198_ p_ll\[18\] VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__and2_1
XFILLER_98_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_2_Right_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1112_ clknet_4_14_0_clk_regs _0133_ VGND VGND VPWR VPWR mid_sum\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1043_ clknet_4_8_0_clk_regs _0064_ VGND VGND VPWR VPWR term_mid\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_190_2_4146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_4_3616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_164_3_Left_1361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_175_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_156_2_3848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0827_ _0336_ _0332_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__and2_1
X_0758_ _0255_ _0256_ _0263_ _0264_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_157_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_149_1_Right_1255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0689_ _0212_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__nand2_1
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_229_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0596__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_1_Left_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_229_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_ll_out[9] p_ll\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_3_3389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_174_3_3993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_205_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_226_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3_3908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_175_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_192_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_4_3581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input34_A b[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_2_3322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_1_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_1_Right_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_165_1_Left_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_142_2_3778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_195_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_1196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_1174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire150 p_lh\[14\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_26_2_Left_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire172 net120 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_4
Xwire183 net102 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_4
XFILLER_117_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire161 p_hh\[26\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_200_1_Right_1306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0612_ net186 net283 VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__and2_1
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_193_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0543_ net186 p_ll\[1\] VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__and2_1
XFILLER_6_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0678__B1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_2_Right_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1026_ clknet_4_5_0_clk_regs _0047_ VGND VGND VPWR VPWR term_high\[47\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_101_1_Right_980 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0863__B p_lh\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_165_3_Left_1362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_202_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_1263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_163_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_208_3_4334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_4_Left_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_176_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1023 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_122_1_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_3_Left_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_lh_in2[12] net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_2_3252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_1327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_183_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0773__B net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_183_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_213_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_3_3540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_145_2_Right_1433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_3_3505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_165_3_3894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_212_1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_X net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold80 p_hh_pipe\[11\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_110_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold91 p_hh_pipe\[1\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_91_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0964__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_1_Right_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_200_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_2_3278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_1278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_1_Left_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_2_Left_927 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0593__B net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[60] net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_165_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1009_ clknet_4_3_0_clk_regs _0030_ VGND VGND VPWR VPWR p_ll_pipe\[30\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_102_1_Right_981 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_1279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_3_3470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_228_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_195_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[11] net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0823__B1 p_hl\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_206_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[22] p_hl\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_143_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_166_3_Left_1363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_184_3_4094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_3_3429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_195_3_4201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_hh_in2[5] net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_176_3_4009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_224_2987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_200_3_4252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_4_3621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_186_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_157_2_3853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_1177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0959__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_150_2_3818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net70 VGND VGND VPWR VPWR p[13] sky130_fd_sc_hd__buf_2
XFILLER_218_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput81 net81 VGND VGND VPWR VPWR p[23] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR p[33] sky130_fd_sc_hd__buf_2
XFILLER_218_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_3_3394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_177_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_203_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_3_Right_1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_0_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_0_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_46_1_Right_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_1_Left_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_167_3_3924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_3_3359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_919 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_173_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0869__A p_hl\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_173_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_4_3551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2_3783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_103_1_Right_982 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_in2[4] net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_217_2791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_167_3_Left_1364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_217_2780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_963 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_3_3649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_219_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_1_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_2_Left_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_1261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output103_A net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0961__B p_hh\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_159_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3_3978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0860_ _0362_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2_1
XFILLER_179_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0791_ _0300_ _0302_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand2_1
XFILLER_182_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_1370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_1289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire142_X net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_2_3318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_4_Left_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_225_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_1_Right_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0989_ clknet_4_13_0_clk_regs _0010_ VGND VGND VPWR VPWR p_ll_pipe\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0599__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_3_3510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_1334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_210_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_3_4167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_219_2853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_104_1_Right_983 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_out[26] net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_110_1_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_1250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_215_2728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_195_2_Right_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input64_A b[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_207_3_4319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_168_3_Left_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_164_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_2_3283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_4_Left_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0956__B p_hh\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_2_3248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_185_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_1330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0972__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_198_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0912_ _0399_ _0410_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or3_1
XANTENNA_max_cap187_X net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_204_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0843_ _0309_ _0327_ _0332_ _0342_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nand4_1
XFILLER_119_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_200_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_3_3434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0774_ net151 p_hl\[13\] VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__nand2b_1
XFILLER_6_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_1201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_229_3160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_211_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_1018 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_4_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_1_Right_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1007__CLK clknet_4_2_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_165_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_2_3823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1157__CLK clknet_4_12_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_981 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_159_1_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_203_3_Left_1400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_180_1285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_105_1_Right_984 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_3_3364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_3_4079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_169_3_Left_1366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_204_1_Left_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0967__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1111_ clknet_4_9_0_clk_regs _0132_ VGND VGND VPWR VPWR mid_sum\[3\] sky130_fd_sc_hd__dfxtp_1
X_1042_ clknet_4_15_0_clk_regs _0063_ VGND VGND VPWR VPWR term_high\[63\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_clkbuf_1_1__f_clk_X clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_137_1_Left_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_1197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_122_3_Right_1092 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_1311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_1_Left_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_3_Right_1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0826_ _0335_ net134 _0334_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__o21ai_2
XFILLER_200_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0757_ _0267_ _0268_ _0272_ _0273_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_136_2_3747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0688_ p_hl\[3\] net145 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand2_1
XFILLER_213_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_116_2_3667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_1_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_ll_out[8] p_ll\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_226_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_174_3_3994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_205_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_1_Right_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3_3909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_2_Left_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_13_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_13_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_49_1368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_3_Left_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_2_3323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A a[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_217_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_154_3_Right_1124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_204_3_Left_1401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_106_1_Right_985 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire140 p_lh\[8\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_4
XFILLER_201_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire173 net119 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_4
Xwire184 net101 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_122_2_3677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire162 p_hh\[25\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_4
Xwire151 p_lh\[13\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_4
XANTENNA_output95_A net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0611_ net186 net287 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__and2_1
XFILLER_109_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0542_ net186 p_ll\[0\] VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__and2_1
XFILLER_125_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_4_Left_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_193_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_993 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1025_ clknet_4_5_0_clk_regs _0046_ VGND VGND VPWR VPWR term_high\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_223_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_2_Right_1414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_170_1_Right_1276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_198_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0809_ _0279_ _0313_ _0319_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__o21bai_2
XFILLER_172_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_210_1_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_217_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_162_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_lh_in2[11] net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_out[22] p_hh\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_2_3253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_1339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_204_2_4285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_165_4_Left_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0841__A1 p_hl\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_220_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_187_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_190_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_4_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3_4030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3_3895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_3_3404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_1023 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold81 p_ll_pipe\[15\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_212_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold92 p_hh_pipe\[19\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 p_hh_pipe\[0\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_36_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0964__B p_hh\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_229_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_1145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_211_2_Right_1499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_205_3_Left_1402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_1_Right_986 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 _0082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire172_X net172 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_1_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1008_ clknet_4_0_0_clk_regs _0029_ VGND VGND VPWR VPWR p_ll_pipe\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_1269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0823__A1 p_hl\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_in2[10] net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0823__B2 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[21] p_hl\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_172_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_195_3_4202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[4] net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_200_3_4253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_2988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_1325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_3_Right_1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_1281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_1112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_194_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_2_3752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_146_1_Left_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0959__B p_hh\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_194_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput71 net71 VGND VGND VPWR VPWR p[14] sky130_fd_sc_hd__buf_2
Xoutput82 net82 VGND VGND VPWR VPWR p[24] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR p[34] sky130_fd_sc_hd__buf_2
XFILLER_190_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_1_Left_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0975__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_130_2_3717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0694__B net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_1269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_1149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_3_3395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1021__D _0042_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_206_3_Left_1403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_108_1_Right_987 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0869__B p_lh\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_931 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1040__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_953 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_1129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0885__A p_hl\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_210_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_1_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_4_3546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_3_Left_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_lh_in2[3] net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_217_2792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2_3682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_184_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0779__B net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_953 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_975 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0732__B1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1106__D _0127_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_219_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0795__A p_hl\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_189_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_1_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_280 VGND VGND VPWR VPWR i_add_280/HI net280 sky130_fd_sc_hd__conb_1
XFILLER_2_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_3_4114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_4_Left_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_214_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_173_3_3979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_1207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0790_ _0299_ _0301_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nor2_1
XFILLER_228_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_3_4340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1063__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_182_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_3_Left_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_1073 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_956 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_989 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_4_3476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_177_1_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_224_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_225_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_2_3217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_162_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_2_Right_1464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_1329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0988_ clknet_4_8_0_clk_regs _0009_ VGND VGND VPWR VPWR p_ll_pipe\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_158_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_203_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_207_3_Left_1404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_1_Right_988 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_912 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_173_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0714__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_A a[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_210_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_3_4168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3_3859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1086__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[25] net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_110_1_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_219_2832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_4_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_219_2854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_164_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input57_A b[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_156_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_1393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_1257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_1342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_219_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input12_X net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_1348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0972__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_222_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_222_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_2_Left_1170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_164_1_Right_1270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_221_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0911_ p_hl\[27\] p_lh\[27\] p_hl\[26\] p_lh\[26\] VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__o211a_1
XFILLER_204_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0842_ _0341_ _0348_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__and3_1
XFILLER_200_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0773_ p_hl\[13\] net151 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_57_3_3435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_1_Left_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_225_3014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3_3789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_i_hl_out[8] p_hl\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_146_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0935__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_208_3_Left_1405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_181_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2_3722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input4_X net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_1_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_3_Right_1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_155_1_Left_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_1_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_196_1_Right_1302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_205_2_Right_1493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_1_Left_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_2_Left_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3_3930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_3_3365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0926__B1 p_hl\[28\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0600__X _0058_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__0967__B net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1110_ clknet_4_9_0_clk_regs _0131_ VGND VGND VPWR VPWR mid_sum\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1041_ clknet_4_5_0_clk_regs _0062_ VGND VGND VPWR VPWR term_high\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_222_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_1323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_226_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_156_2_Left_1171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_175_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_198_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_204_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_4_3516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0825_ _0307_ _0308_ _0325_ _0326_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__or4_1
X_0756_ _0272_ _0271_ net187 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_136_2_3748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_1217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0687_ p_hl\[3\] net145 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__or2_2
XFILLER_116_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_3_Left_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_217_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_211_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[7] p_ll\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_clk_regs_A clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_135_3_Right_1105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_1267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_176_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_3_3289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1124__CLK clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_209_3_Left_1406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_1648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_4_3481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_151_1_Right_1257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_204_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_2_3222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire141 p_lh\[7\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_8
XFILLER_117_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire130 _0160_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
XFILLER_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire174 net118 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_4
Xwire163 p_hh\[24\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_4
Xwire152 p_lh\[12\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_4
Xwire185 net100 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_4
X_0610_ net186 net286 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_122_2_3678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output88_A net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0978__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0541_ net65 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkinv_16
XFILLER_109_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_961 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire162_A p_hh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_1205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_193_3_4184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_103_2_Left_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1024_ clknet_4_5_0_clk_regs _0045_ VGND VGND VPWR VPWR term_high\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_160_3_3870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3_3864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_210_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_2_Left_1172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1147__CLK clknet_4_0_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_159_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3_3829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_199_2_4235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0808_ _0278_ _0312_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a21oi_1
XFILLER_146_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0888__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0739_ _0253_ _0257_ net187 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__a21oi_1
XFILLER_131_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_i_hh_out[21] p_hh\[21\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_i_lh_in2[10] net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_213_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_204_2_4286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_212_Left_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0841__A2 p_lh\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_224_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_1671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_3_3440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_221_Left_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_216_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_190_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_1095 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3_4031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_3_Right_1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_3_3405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_188_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold82 p_ll_pipe\[16\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 p_ll_pipe\[9\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 mid_sum\[23\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_output126_A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_225_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_145_3_3794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_1565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_1205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_925 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_118_1_Left_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_2 _0159_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1019__D _0040_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_193_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire165_X net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_1_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1105__Q term_low\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_212_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1007_ clknet_4_2_0_clk_regs _0028_ VGND VGND VPWR VPWR p_ll_pipe\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_223_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0823__A2 p_lh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_195_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_158_2_Left_1173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_out[20] p_hl\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_3_3370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_995 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_1_Right_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_195_3_4203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[3] net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_164_1_Left_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_172_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_3_3329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_2_Left_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_213_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_200_3_4254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_224_2989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_4_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_186_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_213_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_1668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_4_3521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0737__A_N net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_137_2_3753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_194_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_206_2_4305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput94 net94 VGND VGND VPWR VPWR p[35] sky130_fd_sc_hd__buf_2
XFILLER_190_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput72 net72 VGND VGND VPWR VPWR p[15] sky130_fd_sc_hd__buf_2
Xoutput83 net83 VGND VGND VPWR VPWR p[25] sky130_fd_sc_hd__buf_2
XANTENNA_input42_X net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0975__B net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_130_2_3718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_188_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_4_Left_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_220_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_3_3294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_173_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_987 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload11_A clknet_4_11_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_3_3259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0741__A1 p_hl\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__0741__B2 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_228_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0885__B p_lh\[25\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_167_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[2] net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[41] net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_4_3451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_217_2793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_217_2782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_159_2_Left_1174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_123_2_3683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_178_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_213_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_213_2668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_1_Right_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0732__A1 _0250_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0795__B p_lh\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_1241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_281 VGND VGND VPWR VPWR i_add_281/HI net281 sky130_fd_sc_hd__conb_1
Xi_add_270 VGND VGND VPWR VPWR i_add_270/HI net270 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_157_2_Right_1445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_1311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1122__D _0143_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_1219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_196_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_153_3_3834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_3_4341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_112_2_Left_926 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_182_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_2_4065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_1_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output70_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_1353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_in2[37] term_mid\[37\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_968 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1050 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_1471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_4_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_2_3218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_162_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_203_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0987_ clknet_4_9_0_clk_regs _0008_ VGND VGND VPWR VPWR p_ll_pipe\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_118_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_218_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_154_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__0896__A _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_3_3410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_210_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_rst net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_221_2915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_192_3_4169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_2904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_145_1_Right_1251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_215_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_179_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_i_add_out[24] net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_219_2844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_215_2719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1117__D _0138_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_1_Right_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_1_Left_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_219_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1030__CLK clknet_4_4_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_1093 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0910_ p_hl\[25\] p_lh\[25\] _0392_ _0400_ _0391_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__o2111a_1
XFILLER_221_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0841_ p_hl\[19\] p_lh\[19\] _0331_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__o21ai_1
X_0772_ p_hl\[13\] net151 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
XFILLER_200_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1027__D _0048_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_229_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_3_3334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_1_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_211_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_3_Right_1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_211_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_209_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_205_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_2_Left_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_161_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_181_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2_3723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_1696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1023__Q term_high\[44\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_216_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_223_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_1295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_168_3_3931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_4_Left_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_3_Left_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0926__A1 p_hl\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_3_3264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1033 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_1_Right_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_909 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_207_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1040_ clknet_4_4_0_clk_regs _0061_ VGND VGND VPWR VPWR term_high\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_228_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_207_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_hh VGND VPWR clknet_1_0__leaf_clk net8 net19 net20 net21 net22 net24 net25 net9
+ net10 net11 net13 net14 net15 net16 net17 net18 net40 net51 net52 net53 net54 net56
+ net57 net41 net42 net43 net45 net46 net47 net48 net49 net50 p_hh\[0\] p_hh\[10\]
+ p_hh\[11\] p_hh\[12\] p_hh\[13\] p_hh\[14\] p_hh\[15\] p_hh\[16\] p_hh\[17\] p_hh\[18\]
+ p_hh\[19\] p_hh\[1\] p_hh\[20\] p_hh\[21\] p_hh\[22\] p_hh\[23\] p_hh\[24\] p_hh\[25\]
+ p_hh\[26\] p_hh\[27\] p_hh\[28\] p_hh\[29\] p_hh\[2\] p_hh\[30\] p_hh\[31\] p_hh\[3\]
+ p_hh\[4\] p_hh\[5\] p_hh\[6\] p_hh\[7\] p_hh\[8\] p_hh\[9\] net65 mult_16x16
XFILLER_226_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_ll VGND VPWR clknet_1_1__leaf_clk net1 net2 net3 net4 net5 net6 net7 net12 net23
+ net26 net27 net28 net29 net30 net31 net32 net33 net34 net35 net36 net37 net38 net39
+ net44 net55 net58 net59 net60 net61 net62 net63 net64 p_ll\[0\] p_ll\[10\] p_ll\[11\]
+ p_ll\[12\] p_ll\[13\] p_ll\[14\] p_ll\[15\] p_ll\[16\] p_ll\[17\] p_ll\[18\] p_ll\[19\]
+ p_ll\[1\] p_ll\[20\] p_ll\[21\] p_ll\[22\] p_ll\[23\] p_ll\[24\] p_ll\[25\] p_ll\[26\]
+ p_ll\[27\] p_ll\[28\] p_ll\[29\] p_ll\[2\] p_ll\[30\] p_ll\[31\] p_ll\[3\] p_ll\[4\]
+ p_ll\[5\] p_ll\[6\] p_ll\[7\] p_ll\[8\] p_ll\[9\] net187 mult_16x16
XFILLER_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_222_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_175_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0824_ p_hl\[17\] net148 _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o21ai_1
XFILLER_204_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_200_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0755_ _0261_ _0265_ _0262_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a21boi_1
X_0686_ _0205_ _0211_ _0210_ net186 _0209_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o311a_1
XFILLER_143_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_1401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1076__CLK clknet_4_10_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_1077 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_1_Right_1238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_211_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_ll_out[6] p_ll\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_211_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_225_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1169_ clknet_4_13_0_clk_regs _0190_ VGND VGND VPWR VPWR p_hh_pipe\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_212_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_225_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_3_4120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_155_4_Left_969 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_212_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_4_Left_906 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_175_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_4_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_1397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_197_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_953 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_206_1_Right_1312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_2_3223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_227_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_157_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_1166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire131 _0161_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
XFILLER_201_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire175 net117 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_4
Xwire142 p_lh\[6\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_4
XFILLER_172_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire164 p_hh\[23\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_4
XFILLER_116_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire153 p_lh\[11\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_4
XFILLER_201_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0978__B net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0540_ net149 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__inv_2
XFILLER_10_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_78_4_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_1217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire155_A p_lh\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_1_Right_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1023_ clknet_4_7_0_clk_regs _0044_ VGND VGND VPWR VPWR term_high\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_159_3_3865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__0835__B1 _0198_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_201_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_223_989 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_159_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_199_2_4236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0807_ _0294_ _0296_ _0303_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__a31o_1
X_0738_ _0255_ _0256_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand2_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_3_Right_1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_226_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0669_ net186 net326 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__and2_1
XFILLER_131_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_213_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_i_hh_out[20] p_hh\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_162_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_1308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_214_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_203_1_Left_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_225_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_1341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_187_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_1683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_1429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_1_Left_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_1_Left_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3_4032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_216_1161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold50 p_ll_pipe\[24\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_23_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input32_A a[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold72 mid_sum\[24\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 p_hh_pipe\[28\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 mid_sum\[13\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_188_1569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3_3795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output119_A net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_217_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_189_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_3_3304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_1169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_937 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_2_3965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_199_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_1_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_201_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_3 p_hh_pipe\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_166_3_Right_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_193_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_227_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire158_X net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_1595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_1_Right_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_212_1581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_167_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_3_Right_1087 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_215_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_1352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_2_Left_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_208_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_165_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1006_ clknet_4_4_0_clk_regs _0027_ VGND VGND VPWR VPWR p_ll_pipe\[27\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_11_3_Left_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_1299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_1_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_3_4204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_172_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[2] net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_1481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_1646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_1698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_218_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_185_1709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_6_0_clk_regs_A clknet_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_4_Left_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_183_1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_224_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_3_Left_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0602__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_996 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_206_2_4306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput73 net73 VGND VGND VPWR VPWR p[16] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR p[26] sky130_fd_sc_hd__buf_2
XFILLER_190_1437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput95 net95 VGND VGND VPWR VPWR p[36] sky130_fd_sc_hd__buf_2
XFILLER_7_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input35_X net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[15] net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_161_4_3876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_166_1620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_188_1399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_177_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_195_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_3_3295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_219_1009 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_3_Right_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_164_4_Left_978 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_999 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0741__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_214_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_1275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_138_2_Right_1426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_228_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_182_1_Right_1288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__0690__A2_N net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_1_Right_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_add_out[40] net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_208_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_lh_in2[1] net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_208_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_4_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_178_1513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_4_3446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_176_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_217_2772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_2794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_2669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_191_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_988 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_1621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xdelaybuf_0_clk delaynet_0_clk VGND VGND VPWR VPWR clk_regs sky130_fd_sc_hd__clkbuf_16
XFILLER_120_925 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_194_3_4190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xi_add_260 VGND VGND VPWR VPWR i_add_260/HI net260 sky130_fd_sc_hd__conb_1
XFILLER_219_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_218_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_185_1539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xi_add_282 VGND VGND VPWR VPWR i_add_282/HI net282 sky130_fd_sc_hd__conb_1
Xi_add_271 VGND VGND VPWR VPWR i_add_271/HI net271 sky130_fd_sc_hd__conb_1
XFILLER_2_1253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_1297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_183_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_1323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_202_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3_3835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_209_3_4342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_196_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_182_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_182_2_4066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_1418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_194_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_126_1_Right_1232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_i_add_in2[36] term_mid\[36\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_1682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_227_3090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_1095 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_205_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_162_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_220_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_4_3376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_203_1311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_162_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_202_3_Right_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_1686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0986_ clknet_4_14_0_clk_regs _0007_ VGND VGND VPWR VPWR p_ll_pipe\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_158_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_173_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold43_X net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_218_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_168_3_Right_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_81_3_Right_1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_925 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_1657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_1_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_148_1_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_221_2916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_210_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_221_2905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_1_Right_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_145_1_Left_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_184_1561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_179_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_add_out[23] net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_180_1425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_1_Left_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_1_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_2834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_223_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_219_2856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_180_1469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_219_2845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_2709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_1455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_3_3759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_195_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_178_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_191_1565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_3_Right_1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_1273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_218_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_228_1609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_189_1483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_1339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_219_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_1061 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output101_A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_221_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_163_1656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_1659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_1175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_1028 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0840_ p_hl\[17\] net148 _0333_ _0342_ _0332_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_97_1_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0771_ _0280_ _0284_ _0281_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_105_2_3656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_155_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_150_3_Right_1120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire185_A net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_3_Left_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_229_3141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_229_3185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_3152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_225_3038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3_4017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_3_3335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_3027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_1343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire140_X net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_201_3_4260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_168_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_227_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_224_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_209_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_181_1701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_224_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_209_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_1275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_124_3_3689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_221_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0969_ net186 net165 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__and2_1
XFILLER_118_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_203_3_Right_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_150_3_Left_1347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_122_2_Right_1410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0700__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_169_3_Right_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_216_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_186_1623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_162_4_3881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_1679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_216_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_215_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_1381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_3_Left_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_1_Right_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_1353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_1670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_180_1277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_212_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3_3932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input62_A b[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0926__A2 p_lh\[29\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__0610__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_215_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_191_1373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_3_3265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_215_1045 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_215_1089 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_1409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_219_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_1021 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_207_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkload8_A clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_1065 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_207_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_221_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_1005 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_221_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_1710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_222_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0823_ p_hl\[16\] p_lh\[16\] p_hl\[17\] net148 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__a22o_1
XFILLER_200_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_190_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_1_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_200_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0754_ _0267_ _0269_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nand2b_1
XANTENNA__1038__D _0059_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0685_ p_hl\[1\] net147 p_hl\[2\] net146 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o22ai_4
XFILLER_116_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_174_1593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_4_3416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_1413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_170_1457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_229_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_i_ll_out[5] p_ll\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_211_1465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_188_2_Right_1476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1168_ clknet_4_9_0_clk_regs _0189_ VGND VGND VPWR VPWR p_hh_pipe\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_213_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1099_ clknet_4_9_0_clk_regs _0120_ VGND VGND VPWR VPWR term_low\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_225_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_3_4121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_181_1553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_1662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_181_1597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3_3840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_1321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_204_3_Right_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_175_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_1245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_151_3_Left_1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_880 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_192_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_192_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_1644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1020__CLK clknet_4_6_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_216_1365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_212_1229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_1371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_921 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_965 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_216_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_204_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_1_Right_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_223_1325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_1_Left_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_4_3381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__0605__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire132 _0156_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_12_3_Right_1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire154 p_lh\[10\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_4
Xwire143 p_lh\[5\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_4
Xwire165 p_hh\[22\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_4
XFILLER_8_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire176 net116 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_4
XFILLER_32_1375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_1_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input65_X net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_1706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_1229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_1105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_1_Right_1282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_169_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1022_ clknet_4_6_0_clk_regs _0043_ VGND VGND VPWR VPWR term_high\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_228_1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_222_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_206_1567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_198_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3_3770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3_3764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_198_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_1674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_208_3_4327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0806_ _0293_ _0299_ _0302_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__o21ai_1
XANTENNA__1043__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0737_ net139 p_hl\[9\] VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__nand2b_1
XFILLER_118_1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_154_1_Left_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_226_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3_3729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0668_ net186 net369 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__and2_1
XFILLER_118_1049 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0599_ net186 net292 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__and2_1
XFILLER_112_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_226_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_1_Left_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_2_Left_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_1287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_217_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_1694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_225_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_214_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_187_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_1345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_1337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_194_1711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_1695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1029__Q term_high\[50\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_205_3_Right_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_218_1427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_152_3_Left_1349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_933 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3_4033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_1505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_3_3340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_216_1173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_977 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold40 p_ll_pipe\[4\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_78_3_Right_1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_188_1537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold73 p_hh_pipe\[10\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 p_ll_pipe\[5\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 p_ll_pipe\[7\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A a[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold84 p_hh_pipe\[18\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_112_1193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_3_3305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_189_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1141__D _0162_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_220_905 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_949 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_3_3694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_2_3966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_199_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1066__CLK clknet_4_15_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_223_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_200_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_201_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[15] net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_201_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output93_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_4 p_hh_pipe\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_193_1287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_171_1541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_1694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_1037 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_212_1593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_227_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_1364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_1315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1005_ clknet_4_1_0_clk_regs _0026_ VGND VGND VPWR VPWR p_ll_pipe\[26\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_12_0_clk_regs clknet_0_clk_regs VGND VGND VPWR VPWR clknet_4_12_0_clk_regs
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_223_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_1693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_223_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_182_1681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_1668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_1698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_184_3_4087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_1313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_172_2_Right_1460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_1_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_3_0_clk_regs_X clknet_4_3_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hh_in2[1] net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_147_3_Right_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_3_3270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_217_1493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_213_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_1658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_213_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_160_4_Right_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_226_1707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_1317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_3_3229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_226_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_191_2_4155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1089__CLK clknet_4_8_0_clk_regs VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_224_1497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_220_1317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_194_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_222_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_102_2_Left_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_975 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_206_3_Right_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_4_3421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput74 net74 VGND VGND VPWR VPWR p[17] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR p[27] sky130_fd_sc_hd__buf_2
XFILLER_190_1449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1136__D _0157_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_163_1_Right_1269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput96 net96 VGND VGND VPWR VPWR p[37] sky130_fd_sc_hd__buf_2
XFILLER_27_1263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_1_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_188_1301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_1357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input28_X net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_188_1345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_1119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_i_hl_in2[14] net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_149_1329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_4_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_205_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_1665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_1651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_220_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_4_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_199_1441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_1373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_160_1275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_1289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_199_1485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_1660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3_3917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_1666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_1133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire170_X net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_207_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_147_3_3804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_214_1633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_1341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_1177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
