* NGSPICE file created from add3x64.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_4 abstract view
.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

.subckt add3x64 VGND VPWR clk in1[0] in1[10] in1[11] in1[12] in1[13] in1[14] in1[15]
+ in1[16] in1[17] in1[18] in1[19] in1[1] in1[20] in1[21] in1[22] in1[23] in1[24] in1[25]
+ in1[26] in1[27] in1[28] in1[29] in1[2] in1[30] in1[31] in1[32] in1[33] in1[34] in1[35]
+ in1[36] in1[37] in1[38] in1[39] in1[3] in1[40] in1[41] in1[42] in1[43] in1[44] in1[45]
+ in1[46] in1[47] in1[48] in1[49] in1[4] in1[50] in1[51] in1[52] in1[53] in1[54] in1[55]
+ in1[56] in1[57] in1[58] in1[59] in1[5] in1[60] in1[61] in1[62] in1[63] in1[6] in1[7]
+ in1[8] in1[9] in2[0] in2[10] in2[11] in2[12] in2[13] in2[14] in2[15] in2[16] in2[17]
+ in2[18] in2[19] in2[1] in2[20] in2[21] in2[22] in2[23] in2[24] in2[25] in2[26] in2[27]
+ in2[28] in2[29] in2[2] in2[30] in2[31] in2[32] in2[33] in2[34] in2[35] in2[36] in2[37]
+ in2[38] in2[39] in2[3] in2[40] in2[41] in2[42] in2[43] in2[44] in2[45] in2[46] in2[47]
+ in2[48] in2[49] in2[4] in2[50] in2[51] in2[52] in2[53] in2[54] in2[55] in2[56] in2[57]
+ in2[58] in2[59] in2[5] in2[60] in2[61] in2[62] in2[63] in2[6] in2[7] in2[8] in2[9]
+ in3[0] in3[10] in3[11] in3[12] in3[13] in3[14] in3[15] in3[16] in3[17] in3[18] in3[19]
+ in3[1] in3[20] in3[21] in3[22] in3[23] in3[24] in3[25] in3[26] in3[27] in3[28] in3[29]
+ in3[2] in3[30] in3[31] in3[32] in3[33] in3[34] in3[35] in3[36] in3[37] in3[38] in3[39]
+ in3[3] in3[40] in3[41] in3[42] in3[43] in3[44] in3[45] in3[46] in3[47] in3[48] in3[49]
+ in3[4] in3[50] in3[51] in3[52] in3[53] in3[54] in3[55] in3[56] in3[57] in3[58] in3[59]
+ in3[5] in3[60] in3[61] in3[62] in3[63] in3[6] in3[7] in3[8] in3[9] out[0] out[10]
+ out[11] out[12] out[13] out[14] out[15] out[16] out[17] out[18] out[19] out[1] out[20]
+ out[21] out[22] out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[2] out[30]
+ out[31] out[32] out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[3] out[40]
+ out[41] out[42] out[43] out[44] out[45] out[46] out[47] out[48] out[49] out[4] out[50]
+ out[51] out[52] out[53] out[54] out[55] out[56] out[57] out[58] out[59] out[5] out[60]
+ out[61] out[62] out[63] out[6] out[7] out[8] out[9] rst
XANTENNA__1911__X _0053_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_107_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_116_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input127_A in2[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_125_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input92_A in2[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_134_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1270_ net78 net14 VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__nand2_1
X_1606_ _0855_ _0870_ _0869_ _0846_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o22a_1
X_0985_ net68 net4 net132 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a21o_1
X_1468_ net91 net27 net155 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__nor3_1
X_1537_ _0789_ _0801_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nand2_1
X_1399_ _0675_ _0676_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__nand2_1
XFILLER_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1675__A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1322_ _0602_ _0600_ _0598_ _0589_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a211o_1
X_1253_ _0520_ _0536_ _0538_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__o21ai_1
X_1184_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__inv_2
XANTENNA__1994__D _0052_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput242 net242 VGND VGND VPWR VPWR out[53] sky130_fd_sc_hd__buf_2
Xoutput253 net253 VGND VGND VPWR VPWR out[63] sky130_fd_sc_hd__buf_2
Xoutput231 net231 VGND VGND VPWR VPWR out[43] sky130_fd_sc_hd__buf_2
XANTENNA__1593__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput220 net220 VGND VGND VPWR VPWR out[33] sky130_fd_sc_hd__buf_2
XFILLER_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in1[59] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1441__B net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1871_ net122 net58 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1940_ _0441_ _0301_ net267 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a21oi_1
XANTENNA__1169__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1305_ net80 net16 _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o21ai_1
X_1236_ net75 net11 net139 VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_106_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1167_ _0455_ _0457_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nand3_1
X_1098_ _0384_ _0390_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__o21a_1
XANTENNA__1566__B1 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_129_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1021_ net76 net12 net140 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_29_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1785_ _0127_ _0129_ net179 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__nand3b_2
X_1854_ net121 net57 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor2_1
XANTENNA__1548__B1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1923_ _0382_ _0252_ net264 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o21a_1
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1362__A net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1219_ _0506_ _0507_ _0508_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__o21a_1
XFILLER_37_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input157_A in3[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input18_A in1[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1570_ _0832_ _0834_ _0819_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a21oi_2
XFILLER_112_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1702__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1004_ _0277_ _0278_ _0295_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21ai_1
XANTENNA__1909__X _0052_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1768_ net114 net50 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__and2_1
X_1837_ _0158_ _0161_ _0162_ _0144_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_9_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1906_ net65 net1 net129 net264 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o31ai_1
XFILLER_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1699_ _0737_ _0735_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a21boi_2
Xmax_cap263 _0462_ VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_55_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput186 in3[61] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_1
Xinput175 in3[51] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_1
Xinput164 in3[41] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput153 in3[31] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_1
Xinput142 in3[21] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_1
Xinput131 in3[11] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
Xinput120 in2[5] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_113_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1622_ _0867_ _0871_ _0884_ _0866_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__o211ai_1
XANTENNA__1624__B net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1553_ net97 net33 net161 VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__o21a_1
X_1484_ net92 net28 _0755_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a21o_1
XANTENNA__1923__B1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1445__A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input85_A in2[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input40_X net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0984_ net68 net4 net132 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a21oi_1
X_1605_ _0836_ _0856_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nor2_1
X_1536_ _0788_ _0789_ _0800_ _0801_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand4_1
XANTENNA__1675__A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1467_ _0725_ _0738_ _0741_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__a21oi_1
X_1398_ net86 net22 net150 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1427__A2 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1991__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1321_ _0583_ _0587_ _0598_ _0602_ _0600_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__o221ai_2
X_1252_ _0520_ _0536_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o21a_1
X_1183_ net72 net8 net136 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nor3_1
Xoutput243 net243 VGND VGND VPWR VPWR out[54] sky130_fd_sc_hd__buf_2
Xoutput232 net232 VGND VGND VPWR VPWR out[44] sky130_fd_sc_hd__buf_2
Xoutput221 net221 VGND VGND VPWR VPWR out[34] sky130_fd_sc_hd__buf_2
X_1519_ _0788_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__and2_1
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput210 net210 VGND VGND VPWR VPWR out[24] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput254 net254 VGND VGND VPWR VPWR out[6] sky130_fd_sc_hd__buf_2
XFILLER_114_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input187_A in3[62] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input48_A in1[52] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1870_ _0208_ _0204_ net266 _0209_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__o211a_1
XFILLER_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1304_ net80 net16 net144 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a21o_1
XFILLER_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1166_ _0288_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nand2_1
X_1235_ _0518_ _0522_ _0523_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__a21oi_1
X_1097_ _0380_ _0373_ _0367_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__a21boi_1
XFILLER_109_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1566__A1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1999_ clknet_3_2_0_clk _0057_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dfxtp_1
XFILLER_125_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_137_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input102_A in2[43] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1020_ _0313_ _0305_ _0306_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__nand3b_2
XFILLER_38_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1922_ _0349_ _0355_ _0247_ _0390_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o31a_1
X_1784_ net115 net51 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__nand2_1
X_1853_ _0192_ _0182_ net269 _0193_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__a211oi_1
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1149_ _0442_ _0290_ net267 VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21oi_1
XFILLER_1_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1218_ _0507_ _0506_ net267 VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input105_X net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_77_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1463__A _0737_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1466__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1003_ net68 net4 _0279_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_131_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1905_ net129 _0321_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand2_1
XANTENNA__1218__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1767_ net114 net50 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__nor2_1
X_1836_ _0176_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nand2_1
X_1698_ _0841_ _0951_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput110 in2[50] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_78_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1948__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput176 in3[52] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input30_A in1[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput121 in2[60] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
Xinput165 in3[42] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_1
Xinput187 in3[62] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_1
Xinput154 in3[32] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput143 in3[22] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput132 in3[12] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
XFILLER_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_113_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ _0866_ _0873_ _0884_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__a21o_1
X_1552_ _0818_ _0819_ net161 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__o21bai_2
XFILLER_98_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1483_ net92 net28 net156 VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1819_ _0159_ _0160_ net181 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__o21bai_1
XFILLER_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1550__B net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input78_A in2[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_39_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input33_X net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0983_ net68 net4 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__nor2_1
X_1604_ _0823_ _0837_ _0836_ _0857_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a211o_1
X_1535_ _0803_ _0804_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_57_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1466_ _0722_ _0724_ _0739_ net270 VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a31o_1
X_1397_ net86 net22 VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_80_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout265_A _0276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_3_1_0_clk_X clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input132_A in3[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1320_ _0599_ _0601_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__and2_1
X_1182_ _0472_ _0473_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__nor2_1
X_1251_ _0516_ _0531_ _0532_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21boi_1
XFILLER_91_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput200 net200 VGND VGND VPWR VPWR out[15] sky130_fd_sc_hd__buf_2
Xoutput233 net233 VGND VGND VPWR VPWR out[45] sky130_fd_sc_hd__buf_2
Xoutput244 net244 VGND VGND VPWR VPWR out[55] sky130_fd_sc_hd__buf_2
X_1449_ _0716_ _0717_ _0721_ _0714_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__o211ai_2
Xoutput222 net222 VGND VGND VPWR VPWR out[35] sky130_fd_sc_hd__buf_2
X_1518_ net93 net29 _0769_ _0785_ _0787_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__o2111ai_4
Xoutput211 net211 VGND VGND VPWR VPWR out[25] sky130_fd_sc_hd__buf_2
Xoutput255 net255 VGND VGND VPWR VPWR out[7] sky130_fd_sc_hd__buf_2
XFILLER_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1303_ net80 net16 net144 VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a21oi_1
XFILLER_64_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1165_ _0289_ _0299_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__nand2_1
X_1234_ _0518_ _0522_ net265 VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__o21ai_1
X_1096_ _0336_ _0346_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__o21ai_1
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1998_ clknet_3_2_0_clk _0056_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dfxtp_1
XFILLER_125_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input60_A in1[63] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload6_A clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1852_ _0176_ _0182_ _0191_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__a21oi_1
XFILLER_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1921_ _0250_ _0251_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__nor2_1
X_1783_ net115 net51 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__and2_1
XFILLER_115_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1643__B net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1181__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1148_ _0301_ _0441_ _0299_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__o21a_1
X_1079_ _0268_ _0363_ _0372_ _0361_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__o211ai_2
X_1217_ _0495_ _0485_ _0483_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_35_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1002_ net68 net4 net132 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nand3_1
X_1835_ _0169_ _0175_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__nand2_1
X_1904_ net271 _0239_ _0240_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_32_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1766_ _0110_ _0111_ _0112_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__o21a_1
XFILLER_103_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1654__A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1697_ _0951_ _0844_ _0954_ _0953_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__o2111ai_4
XFILLER_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput122 in2[61] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
Xinput111 in2[51] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_2
XANTENNA__1564__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput100 in2[41] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__buf_2
Xinput144 in3[23] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
Xinput133 in3[13] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input162_A in3[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput177 in3[53] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_1
Xinput155 in3[33] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_113_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput166 in3[43] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_1
Xinput188 in3[63] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_86_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_A in1[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1620_ _0882_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nand2_1
X_1551_ net97 net33 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_1
X_1482_ net92 net28 net156 VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__o21a_1
XFILLER_97_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1818_ _0159_ _0160_ net181 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_60_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1749_ _0071_ _0072_ _0085_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__nand3_1
XFILLER_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input26_X net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_103_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0982_ net270 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__inv_2
XFILLER_12_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_112_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1603_ _0823_ _0837_ _0855_ _0856_ _0836_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__a2111oi_1
X_1465_ _0722_ _0724_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__and3_1
X_1534_ _0789_ _0791_ _0802_ net270 VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_121_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1396_ net86 net22 VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__and2_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input125_A in2[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input90_A in2[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1181_ _0453_ _0461_ _0471_ net267 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a31o_1
X_1250_ _0482_ _0483_ _0506_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nor4_1
Xoutput234 net234 VGND VGND VPWR VPWR out[46] sky130_fd_sc_hd__buf_2
Xoutput223 net223 VGND VGND VPWR VPWR out[36] sky130_fd_sc_hd__buf_2
Xoutput212 net212 VGND VGND VPWR VPWR out[26] sky130_fd_sc_hd__buf_2
Xoutput201 net201 VGND VGND VPWR VPWR out[16] sky130_fd_sc_hd__buf_2
Xoutput245 net245 VGND VGND VPWR VPWR out[56] sky130_fd_sc_hd__buf_2
X_1448_ _0714_ _0720_ _0721_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__and3_1
X_1517_ _0766_ _0769_ _0785_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a22o_1
XFILLER_74_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput256 net256 VGND VGND VPWR VPWR out[8] sky130_fd_sc_hd__buf_2
XFILLER_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1379_ net85 net21 net149 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
XFILLER_128_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1302_ net80 net16 net144 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nand3_1
X_1233_ _0504_ _0519_ _0495_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a22oi_2
X_1164_ _0290_ _0301_ _0441_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__or3_1
X_1095_ _0347_ _0354_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand2_1
X_1997_ clknet_3_3_0_clk _0055_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dfxtp_1
XFILLER_133_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1565__B1_N net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input192_A in3[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_A in1[57] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1851_ _0175_ _0169_ _0190_ _0189_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__o22a_1
XFILLER_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1920_ _0349_ _0354_ _0249_ net267 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a31o_1
X_1782_ net115 net51 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__nor2_1
XFILLER_115_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1216_ _0504_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
X_1147_ _0420_ _0431_ _0436_ _0394_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__o41a_1
X_1078_ _0364_ _0368_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_35_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1935__B1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1001_ _0277_ _0273_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1834_ _0175_ _0169_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__or2_1
X_1765_ _0111_ _0110_ net269 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a21oi_1
X_1903_ _0224_ _0233_ _0238_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__o21a_1
XANTENNA__1971__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1654__B net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1696_ _0919_ _0935_ _0936_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a21bo_1
XANTENNA__1926__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput167 in3[44] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_1
Xinput178 in3[54] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_1
Xinput112 in2[52] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input155_A in3[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput123 in2[62] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
Xinput101 in2[42] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_86_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput156 in3[34] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_1
Xinput145 in3[24] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_1
Xinput134 in3[14] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input16_A in1[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput189 in3[6] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_2
XFILLER_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1550_ net97 net33 VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nor2_1
X_1481_ net92 net28 VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__and2_1
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1817_ net117 net53 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__and2_1
X_1748_ _0094_ _0095_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__nand2_1
X_1679_ _0919_ _0927_ _0937_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__a21oi_1
XANTENNA_input8_A in1[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0981_ net137 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__inv_2
X_1602_ _0865_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nand2_1
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1464_ _0737_ _0735_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nand2_2
X_1533_ _0789_ _0791_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a21oi_1
X_1395_ net86 net22 VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor2_1
XFILLER_128_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input118_A in2[58] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input83_A in2[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1180_ _0453_ _0461_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a21oi_1
Xoutput246 net246 VGND VGND VPWR VPWR out[57] sky130_fd_sc_hd__buf_2
Xoutput224 net224 VGND VGND VPWR VPWR out[37] sky130_fd_sc_hd__buf_2
Xoutput235 net235 VGND VGND VPWR VPWR out[47] sky130_fd_sc_hd__buf_2
X_1516_ net94 net30 _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a21o_1
Xoutput213 net213 VGND VGND VPWR VPWR out[27] sky130_fd_sc_hd__buf_2
Xoutput202 net202 VGND VGND VPWR VPWR out[17] sky130_fd_sc_hd__buf_2
Xoutput257 net257 VGND VGND VPWR VPWR out[9] sky130_fd_sc_hd__buf_2
XFILLER_114_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1447_ _0720_ _0721_ _0714_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a21o_1
X_1378_ _0656_ _0657_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__nor2_1
XFILLER_130_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout270_A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1301_ net80 net16 net144 VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__or3_1
X_1232_ _0485_ _0504_ _0505_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__and3_1
X_1163_ _0288_ _0289_ _0299_ _0300_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__and4_1
X_1094_ _0356_ _0383_ _0386_ _0331_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__nand4_1
XFILLER_109_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1996_ clknet_3_3_0_clk _0054_ VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dfxtp_1
XFILLER_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input185_A in3[60] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload0 clknet_3_0_0_clk VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_4
XFILLER_132_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input46_A in1[50] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout270 net271 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
XFILLER_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1850_ _0189_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__or2_1
X_1781_ net266 _0125_ _0126_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and3_1
XANTENNA__1650__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1146_ _0420_ _0438_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__o21a_1
X_1215_ _0503_ _0480_ _0498_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__nand3_1
X_1077_ _0364_ _0268_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1979_ clknet_3_5_0_clk _0037_ VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dfxtp_1
XFILLER_136_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input100_A in2[41] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1000_ _0270_ _0271_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__o21ai_1
X_1902_ _0232_ _0226_ _0224_ _0238_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_17_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1833_ _0173_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__nand2_1
X_1764_ _0096_ _0100_ _0094_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__o21ai_1
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1695_ _0910_ _0922_ _0937_ _0925_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__or4_1
XFILLER_122_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1129_ net127 net63 VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_63_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput179 in3[55] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_1
Xinput113 in2[53] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
Xinput102 in2[43] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
Xinput124 in2[63] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput168 in3[45] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_2
Xinput157 in3[35] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input148_A in3[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput146 in3[25] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput135 in3[15] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input103_X net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1853__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1480_ net92 net28 VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1816_ net117 net53 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nor2_1
X_1747_ net111 net47 _0091_ _0092_ _0080_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a221o_1
X_1678_ _0919_ _0927_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1961__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0980_ net134 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__inv_2
XFILLER_12_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1601_ net100 net36 _0852_ _0862_ _0864_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__o2111ai_4
X_1532_ _0800_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand2_1
XFILLER_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1463_ _0737_ _0735_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__and2_1
X_1394_ _0665_ _0670_ _0664_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_26_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1395__B net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1587__A2 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input76_A in2[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput236 net236 VGND VGND VPWR VPWR out[48] sky130_fd_sc_hd__buf_2
Xoutput247 net247 VGND VGND VPWR VPWR out[58] sky130_fd_sc_hd__buf_2
Xoutput225 net225 VGND VGND VPWR VPWR out[38] sky130_fd_sc_hd__buf_2
X_1515_ net94 net30 net158 VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__o21ai_1
Xoutput214 net214 VGND VGND VPWR VPWR out[28] sky130_fd_sc_hd__buf_2
Xoutput203 net203 VGND VGND VPWR VPWR out[18] sky130_fd_sc_hd__buf_2
X_1446_ _0715_ _0716_ net154 VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__o21bai_1
XFILLER_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1377_ _0637_ _0642_ _0655_ net270 VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a31o_1
XFILLER_67_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_61_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input130_A in3[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1300_ net80 net16 net144 VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nor3_1
X_1162_ _0452_ _0453_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__nand2_1
X_1231_ _0504_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand2_1
XFILLER_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1093_ _0385_ _0384_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nor2_1
XFILLER_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1995_ clknet_3_3_0_clk _0053_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dfxtp_1
X_1429_ _0700_ _0702_ net153 VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__o21bai_2
XANTENNA_fanout266_X net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_3_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__bufinv_16
XFILLER_34_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input178_A in3[54] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input39_A in1[44] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout271 net193 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_4
XFILLER_131_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1780_ _0124_ _0121_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__nand2_1
XFILLER_91_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1145_ _0407_ _0417_ _0415_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a21boi_1
X_1214_ _0498_ _0503_ _0480_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a21o_1
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1076_ _0268_ _0364_ _0363_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__o21a_1
X_1978_ clknet_3_5_0_clk _0036_ VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dfxtp_1
XFILLER_106_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1699__A1 _0737_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkload4_A clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1832_ _0170_ _0171_ net182 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o21bai_1
X_1901_ _0235_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_17_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1763_ _0108_ _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__nor2_1
X_1694_ _0952_ _0950_ _0923_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand3_1
XFILLER_111_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1128_ net127 net63 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1059_ _0336_ _0350_ _0351_ _0312_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__o211ai_1
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput103 in2[44] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_2
Xinput114 in2[54] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_2
XFILLER_102_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput169 in3[46] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_1
Xinput158 in3[36] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_1
Xinput147 in3[26] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_1
XFILLER_56_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput136 in3[16] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
Xinput125 in2[6] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_2
XFILLER_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1815_ net180 _0140_ _0139_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_99_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1746_ _0077_ _0080_ _0091_ _0092_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__o211ai_1
X_1677_ _0935_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nand2_1
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_3_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input160_A in3[38] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A in1[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1600_ net100 net36 _0862_ _0864_ _0853_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a221o_1
X_1531_ _0794_ net159 _0793_ _0798_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o211ai_2
XFILLER_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1462_ _0494_ _0492_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__o21bai_4
XFILLER_94_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1393_ _0665_ _0670_ _0671_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__o21ba_1
XFILLER_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1753__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1729_ _0076_ _0077_ net175 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__o21bai_2
XFILLER_85_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input163_X net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input69_A in2[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput237 net237 VGND VGND VPWR VPWR out[49] sky130_fd_sc_hd__buf_2
Xoutput248 net248 VGND VGND VPWR VPWR out[59] sky130_fd_sc_hd__buf_2
X_1445_ net90 net26 _0717_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21o_1
X_1514_ _0782_ _0783_ net158 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__o21bai_2
Xoutput226 net226 VGND VGND VPWR VPWR out[39] sky130_fd_sc_hd__buf_2
XFILLER_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput215 net215 VGND VGND VPWR VPWR out[29] sky130_fd_sc_hd__buf_2
Xoutput204 net204 VGND VGND VPWR VPWR out[19] sky130_fd_sc_hd__buf_2
XFILLER_114_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1376_ _0637_ _0642_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1951__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input123_A in2[62] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1161_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__inv_2
X_1092_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__inv_2
X_1230_ _0484_ _0505_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__nand2_1
XANTENNA__1974__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1994_ clknet_3_3_0_clk _0052_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dfxtp_1
XFILLER_118_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1428_ net89 net25 _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a21o_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1359_ _0638_ _0614_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__o21bai_1
XFILLER_34_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload2 clknet_3_2_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_132_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1938__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1213_ net73 net9 _0500_ _0501_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o211ai_1
XFILLER_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1144_ _0429_ _0435_ _0430_ _0426_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__o2bb2ai_1
X_1075_ _0268_ _0364_ _0363_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__o21ai_1
XANTENNA__2002__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1977_ clknet_3_5_0_clk _0035_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_80_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1929__B1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_119_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_128_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input190_A in3[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in1[55] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_137_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1831_ _0170_ _0171_ net182 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__or3b_1
X_1900_ net124 _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__xor2_1
X_1762_ _0090_ _0091_ _0107_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21oi_1
X_1693_ _0855_ _0870_ _0897_ _0899_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__o31ai_1
Xmax_cap258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_95_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1127_ net127 net63 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and2_1
X_1058_ _0333_ _0335_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nand3_1
Xinput115 in2[55] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
Xinput104 in2[45] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput126 in2[7] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_1
XFILLER_102_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput159 in3[37] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_1
Xinput148 in3[27] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput137 in3[17] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
XANTENNA_input99_A in2[40] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1814_ _0145_ _0154_ _0157_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__a21oi_1
X_1745_ _0077_ _0080_ _0091_ _0092_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__o211a_1
XFILLER_7_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1676_ _0933_ _0934_ _0917_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a21o_1
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input153_A in3[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input14_A in1[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1530_ _0784_ _0787_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nand3_1
X_1392_ _0670_ _0665_ net268 VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a21o_1
X_1461_ net261 _0609_ _0727_ _0733_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand4_1
XFILLER_128_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1728_ net111 net47 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and2_2
X_1659_ _0913_ _0917_ _0915_ _0907_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o211ai_2
XFILLER_85_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A in1[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput216 net216 VGND VGND VPWR VPWR out[2] sky130_fd_sc_hd__buf_2
Xoutput205 net205 VGND VGND VPWR VPWR out[1] sky130_fd_sc_hd__buf_2
X_1444_ net90 net26 _0717_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__a21boi_1
X_1513_ net94 net30 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nand2_1
X_1375_ _0651_ _0654_ _0653_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__o21ai_1
Xoutput227 net227 VGND VGND VPWR VPWR out[3] sky130_fd_sc_hd__buf_2
Xoutput238 net238 VGND VGND VPWR VPWR out[4] sky130_fd_sc_hd__buf_2
Xoutput249 net249 VGND VGND VPWR VPWR out[5] sky130_fd_sc_hd__buf_2
XFILLER_4_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input116_A in2[56] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input81_A in2[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1160_ _0445_ _0451_ _0286_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__nand3b_2
X_1091_ _0306_ _0312_ _0308_ _0305_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__a211oi_2
X_1993_ clknet_3_2_0_clk _0051_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dfxtp_1
XFILLER_133_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1427_ net89 net25 net153 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o21ai_2
X_1358_ _0623_ _0605_ _0625_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__o21ai_1
XFILLER_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1289_ net79 net15 _0570_ _0571_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__o211ai_1
Xclkload3 clknet_3_3_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_2
XFILLER_50_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_128_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1212_ _0275_ _0497_ _0499_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1143_ _0426_ _0430_ _0434_ _0435_ _0429_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__o2111a_1
X_1074_ net126 net62 net190 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_102_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1976_ clknet_3_4_0_clk _0034_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout271_X net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input183_A in3[59] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input44_A in1[49] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1964__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1830_ net118 net54 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__nand2_1
X_1761_ _0090_ _0091_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_72_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1692_ _0868_ _0896_ _0923_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand4_2
XFILLER_122_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1126_ _0408_ _0410_ _0415_ _0417_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_130_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1057_ net109 net45 net173 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nand3_1
XFILLER_103_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1959_ clknet_3_3_0_clk _0017_ VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dfxtp_1
XFILLER_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput116 in2[56] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
XANTENNA__1987__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput105 in2[46] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_2
XFILLER_102_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput149 in3[28] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_1
Xinput127 in2[8] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput138 in3[18] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_1
XFILLER_112_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1744_ _0088_ _0089_ net176 VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__o21bai_2
X_1813_ _0145_ _0154_ net266 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__o21ai_1
XFILLER_133_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1675_ net105 net41 _0916_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__o2111ai_2
XFILLER_97_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ net128 net64 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input146_A in3[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1460_ _0613_ _0734_ _0732_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a21oi_2
X_1391_ _0668_ _0640_ _0652_ _0666_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1727_ net111 net47 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1658_ _0907_ _0914_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__nand3b_2
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1589_ _0850_ _0854_ _0849_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a21oi_2
XFILLER_85_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput239 net239 VGND VGND VPWR VPWR out[50] sky130_fd_sc_hd__buf_2
Xoutput228 net228 VGND VGND VPWR VPWR out[40] sky130_fd_sc_hd__buf_2
X_1512_ net94 net30 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__and2_1
Xoutput217 net217 VGND VGND VPWR VPWR out[30] sky130_fd_sc_hd__buf_2
Xoutput206 net206 VGND VGND VPWR VPWR out[20] sky130_fd_sc_hd__buf_2
X_1443_ _0716_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nand2b_1
X_1374_ _0645_ _0648_ _0634_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__o21ai_2
XFILLER_136_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input109_A in2[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input74_A in2[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1090_ _0367_ _0373_ _0379_ _0381_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nand4_1
X_1992_ clknet_3_7_0_clk _0050_ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dfxtp_1
X_1426_ net89 net25 VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nor2_1
X_1357_ _0604_ _0605_ _0624_ _0625_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__nand4_1
XFILLER_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1288_ _0569_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_105_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload4 clknet_3_4_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_50_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1332__B1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1142_ _0434_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nand2_2
X_1211_ net73 net9 net137 VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a21o_1
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1626__A1 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1073_ _0358_ _0359_ _0365_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__o211ai_2
XFILLER_106_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1975_ clknet_3_6_0_clk _0033_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dfxtp_1
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1409_ net88 net24 net152 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nor3_1
XFILLER_29_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_125_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout264_X net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input176_A in3[52] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input37_A in1[42] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1760_ _0103_ _0105_ _0104_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__o21ai_1
XANTENNA__1792__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1691_ _0919_ _0920_ _0935_ _0936_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__and4_1
XFILLER_89_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1125_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_130_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1056_ net109 net45 net173 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nor3_1
XFILLER_33_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1889_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__inv_2
X_1958_ clknet_3_3_0_clk _0016_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput117 in2[57] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
Xinput106 in2[47] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput128 in2[9] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput139 in3[19] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_1
XFILLER_112_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkload2_A clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1743_ _0088_ _0090_ net176 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__nand3b_2
X_1812_ _0148_ _0152_ _0145_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21oi_2
XANTENNA__1765__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1674_ _0929_ _0930_ net170 VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_68_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1108_ net128 net64 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__and2_1
X_1039_ net109 net45 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_86_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1954__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_95_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input139_A in3[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1390_ _0654_ _0651_ _0637_ _0636_ _0653_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o2111ai_2
XANTENNA__0982__Y _0276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1738__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1726_ net266 _0074_ _0075_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and3_1
X_1657_ _0917_ _0915_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__nand2_1
X_1588_ net100 net36 _0851_ _0852_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o211ai_2
XFILLER_37_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1442_ net90 net26 net154 VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__o21ai_2
Xoutput229 net229 VGND VGND VPWR VPWR out[41] sky130_fd_sc_hd__buf_2
X_1511_ net94 net30 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__nor2_1
Xoutput218 net218 VGND VGND VPWR VPWR out[31] sky130_fd_sc_hd__buf_2
Xoutput207 net207 VGND VGND VPWR VPWR out[21] sky130_fd_sc_hd__buf_2
XFILLER_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1373_ _0644_ _0650_ _0634_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__o21bai_2
XFILLER_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2005__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1709_ _0943_ _0946_ _0962_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__a211oi_1
XFILLER_48_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input67_A in2[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_X net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1991_ clknet_3_7_0_clk _0049_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dfxtp_1
X_1425_ net89 net25 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nand2_1
X_1356_ _0629_ _0635_ _0620_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__nand3b_4
XFILLER_55_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1287_ net79 net15 net143 VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_50_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload5 clknet_3_5_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_105_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1644__A2 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_128_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout264 net265 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_4
XFILLER_131_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input121_A in2[60] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1141_ _0421_ _0424_ _0369_ _0432_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__o211ai_4
X_1072_ _0362_ _0364_ _0268_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__o21ai_1
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1210_ net73 net9 net137 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand3_1
XFILLER_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1974_ clknet_3_7_0_clk _0032_ VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dfxtp_1
XANTENNA__1626__A2 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_102_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1408_ _0672_ _0684_ _0685_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_133_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1339_ _0617_ _0619_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__and2_1
XFILLER_126_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input169_A in3[46] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1690_ _0947_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_115_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_124_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1124_ _0415_ _0417_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand2_1
X_1055_ _0347_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_130_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1957_ clknet_3_3_0_clk _0015_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_133_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1888_ _0224_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput118 in2[58] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput107 in2[48] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
Xinput129 in3[0] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1811_ _0147_ _0959_ _0153_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o21bai_1
XFILLER_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1742_ net112 net48 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__nand2_1
X_1673_ net106 net42 _0931_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a21o_1
XFILLER_97_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ net128 net64 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nor2_1
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1038_ net109 net45 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_1
XANTENNA__1205__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input97_A in2[39] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1725_ _0073_ _0071_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__nand2_1
X_1587_ net100 net36 net164 VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__o21a_1
X_1656_ net105 net41 _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__o21a_1
XFILLER_118_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input151_A in3[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in1[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1441_ net90 net26 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__and2_1
Xoutput219 net219 VGND VGND VPWR VPWR out[32] sky130_fd_sc_hd__buf_2
X_1510_ _0739_ net259 _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__a21o_1
Xoutput208 net208 VGND VGND VPWR VPWR out[22] sky130_fd_sc_hd__buf_2
XFILLER_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1372_ _0644_ _0650_ _0630_ _0633_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__o211a_1
XANTENNA__1944__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1708_ _0963_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nor2_1
XFILLER_104_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1639_ _0895_ _0900_ _0901_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__a21oi_1
XANTENNA_input4_A in1[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1638__B1 _0276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1967__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1990_ clknet_3_7_0_clk _0048_ VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dfxtp_1
XFILLER_54_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1424_ net89 net25 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__and2_1
X_1355_ net262 _0634_ _0631_ _0621_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o211ai_4
XFILLER_55_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1286_ net79 net15 net143 VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_105_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload6 clknet_3_6_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_2
XFILLER_50_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout265 _0276_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
XANTENNA_input114_A in2[54] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_136_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_3_4_0_clk_X clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1140_ _0269_ _0422_ _0425_ _0433_ _0370_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__o221ai_4
X_1071_ _0364_ net190 _0363_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nand3b_1
XFILLER_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1973_ clknet_3_7_0_clk _0031_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1336__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1338_ _0617_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand2_2
X_1407_ _0672_ _0684_ net268 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_133_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1269_ net78 net14 net142 VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_34_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1553__A2 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input82_X net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1123_ _0395_ _0396_ _0412_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__o211ai_2
XFILLER_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1054_ _0332_ _0334_ _0337_ _0344_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__o211ai_1
X_1887_ _0221_ _0222_ _0223_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a21oi_1
X_1956_ clknet_3_4_0_clk _0014_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput108 in2[49] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput119 in2[59] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
XANTENNA__1513__B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input181_A in3[57] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input42_A in1[47] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1741_ net112 net48 VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__and2_1
X_1810_ _0099_ _0146_ _0959_ _0152_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_13_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1672_ net106 net42 _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__a21oi_1
XFILLER_97_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1106_ net66 net2 _0397_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__o211ai_2
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1037_ _0327_ _0319_ _0314_ _0320_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__o211ai_4
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput90 in2[32] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlymetal6s2s_1
X_1939_ _0419_ _0262_ _0263_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__o21a_1
XFILLER_21_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1724_ _0960_ _0969_ _0949_ _0071_ _0072_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a311o_1
X_1655_ net105 net41 net169 VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a21o_1
X_1586_ net100 net36 net164 VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21o_1
XFILLER_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input144_A in3[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1440_ net90 net26 VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__nor2_1
X_1371_ _0643_ _0645_ net148 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__o21ba_1
XFILLER_57_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput209 net209 VGND VGND VPWR VPWR out[23] sky130_fd_sc_hd__buf_2
XFILLER_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1656__A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1707_ net108 net44 _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__o21ai_2
X_1638_ _0895_ _0900_ _0276_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__o21ai_1
XFILLER_104_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1569_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__inv_2
XFILLER_120_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_0_0_clk_X clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1354_ net83 net19 _0631_ _0632_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__o211ai_2
X_1423_ _0695_ _0698_ _0699_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__o21a_1
X_1285_ net79 net15 net143 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nand3_1
XFILLER_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout266 _0276_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input107_A in2[48] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input72_A in2[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1426__B net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1070_ net126 net62 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1972_ clknet_3_6_0_clk _0030_ VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dfxtp_1
XFILLER_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1406_ _0680_ _0678_ _0682_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__a21oi_1
X_1337_ net82 net18 net146 VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1268_ net264 _0553_ _0554_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and3_1
XFILLER_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1199_ _0456_ _0486_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1122_ _0270_ _0271_ _0293_ _0413_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_29_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_1_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1053_ _0339_ _0345_ _0336_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nand3b_1
XFILLER_33_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1886_ _0221_ _0222_ _0223_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__and3_1
X_1955_ clknet_3_1_0_clk _0013_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_47_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1940__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput109 in2[4] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_2
XFILLER_112_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input174_A in3[50] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input35_A in1[40] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1740_ net112 net48 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__nor2_1
X_1671_ net106 net42 net170 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire261 _0537_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_1
XFILLER_97_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1105_ net66 net2 net130 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nand3_1
X_1036_ _0327_ _0319_ _0320_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__o21ai_1
XFILLER_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput91 in2[33] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlymetal6s2s_1
X_1869_ _0206_ _0204_ _0200_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o21ai_1
XFILLER_107_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput80 in2[23] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_2
X_1938_ _0262_ _0419_ net267 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1913__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1444__A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkload0_A clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1723_ _0960_ _0969_ _0949_ _0072_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__a31o_1
X_1654_ net105 net41 net169 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_91_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1625__A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1585_ net100 net36 net164 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nand3_1
XFILLER_93_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1019_ _0307_ _0310_ _0308_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a21oi_1
XFILLER_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input137_A in3[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1370_ _0646_ _0648_ _0647_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__a21oi_1
XFILLER_68_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1656__A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1990__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1706_ net108 net44 net172 VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__a21o_1
X_1637_ _0882_ _0898_ _0872_ _0896_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a22oi_4
X_1568_ _0819_ _0821_ _0831_ _0833_ _0832_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__o221ai_2
X_1499_ _0767_ _0770_ _0757_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a21oi_1
XFILLER_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1422_ _0695_ _0698_ net268 VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a21oi_1
X_1353_ _0630_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand2_2
X_1284_ net79 net15 VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_10_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1995__D _0053_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0999_ net67 net3 net131 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__o21ai_2
XFILLER_132_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout267 net271 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
XFILLER_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input65_A in2[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1492__B1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1971_ clknet_3_7_0_clk _0029_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dfxtp_1
XFILLER_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1405_ _0678_ _0679_ _0659_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__a21o_1
X_1336_ net82 net18 net146 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand3_1
X_1198_ _0459_ _0487_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__o21a_1
Xinput1 in1[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
X_1267_ _0552_ _0541_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_34_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1121_ _0292_ _0293_ _0398_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__o211ai_2
X_1052_ _0342_ _0337_ _0339_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__a21oi_1
X_1954_ clknet_3_1_0_clk _0012_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1885_ net122 net58 _0212_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_102_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1319_ _0599_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
XFILLER_24_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input167_A in3[44] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input28_A in1[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1447__B1 _0714_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1670_ net106 net42 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nor2_1
XANTENNA__1448__A _0714_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1947__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1104_ _0395_ _0396_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nor2_1
XANTENNA__1911__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1035_ _0319_ _0327_ _0320_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__or3b_1
X_1937_ _0411_ _0260_ _0408_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1799_ _0129_ _0130_ _0141_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a21o_1
X_1868_ _0200_ _0206_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__or2_1
XFILLER_107_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput92 in2[34] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput81 in2[24] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_1
Xinput70 in2[14] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_2
XFILLER_107_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1268__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1625__B net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1722_ _0947_ _0968_ _0967_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__o21bai_1
X_1653_ net105 net41 net169 VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__or3_1
X_1584_ net100 net36 net164 VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1018_ net98 net34 _0309_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__o21ai_1
XFILLER_78_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input95_A in2[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1726__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1813__B1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1705_ net108 net44 net172 VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__and3_1
X_1636_ _0882_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand2_1
X_1567_ net99 net35 _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a21o_1
X_1498_ net93 net29 _0768_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__o211ai_2
XFILLER_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A in1[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1421_ _0696_ _0670_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__o21bai_1
X_1352_ net83 net19 net147 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__o21ai_1
X_1283_ net79 net15 net143 VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__nor3_1
XANTENNA__1462__Y _0737_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0998_ net67 net3 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__and2_1
XFILLER_132_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1619_ _0875_ _0880_ _0881_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nand3_1
Xfanout268 net271 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input2_A in1[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input58_A in1[61] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1970_ clknet_3_6_0_clk _0028_ VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dfxtp_1
XFILLER_65_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output214_A net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1404_ _0678_ _0679_ _0659_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a21oi_1
X_1335_ net82 net18 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__nand2_1
X_1197_ _0454_ _0469_ _0470_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21boi_1
Xinput2 in1[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
XFILLER_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1266_ _0550_ _0551_ _0495_ _0537_ _0540_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a221o_1
XFILLER_120_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input112_A in2[52] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1120_ _0291_ _0292_ _0272_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__o21ai_1
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1051_ net120 net56 _0337_ _0341_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__o211ai_1
X_1884_ _0219_ _0220_ net187 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__o21bai_1
X_1953_ clknet_3_1_0_clk _0011_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dfxtp_1
XANTENNA__1909__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1318_ net81 net17 net145 VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_121_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1249_ _0515_ _0517_ _0531_ _0532_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand4_2
XFILLER_21_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1464__A _0737_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1103_ net66 net2 net130 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21o_1
X_1034_ _0319_ _0320_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__and2b_1
X_1867_ _0155_ _0203_ _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a21oi_1
X_1936_ _0411_ _0260_ _0261_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1798_ _0129_ _0130_ _0141_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__and3_1
Xinput60 in1[63] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
Xinput93 in2[35] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_2
Xinput71 in2[15] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput82 in2[25] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input40_A in1[45] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_130_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1721_ _0965_ _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__xor2_1
XFILLER_78_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1652_ net105 net41 net169 VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nor3_1
X_1583_ _0831_ _0833_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand2b_1
XANTENNA__1641__B net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1017_ _0307_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
X_1919_ _0354_ _0249_ _0349_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a21oi_1
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1551__B net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input88_A in2[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1704_ net108 net44 net172 VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nor3_1
X_1635_ _0866_ _0883_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__nand2_1
XANTENNA__1652__A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1566_ net99 net35 net163 VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o21ai_2
X_1497_ net93 net29 net157 VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__a21o_1
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input142_A in3[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1420_ _0664_ _0682_ _0681_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o21ai_1
X_1351_ net83 net19 net147 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a21o_1
XFILLER_95_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1282_ _0551_ _0554_ _0565_ _0567_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__a31oi_1
XFILLER_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1618_ _0880_ _0881_ _0875_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__a21o_1
X_0997_ net67 net3 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__nor2_1
XFILLER_115_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout269 net271 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_4
X_1549_ _0808_ _0816_ _0817_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a21oi_1
XFILLER_46_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1713__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_119_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1403_ _0674_ _0676_ _0679_ _0659_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__o211ai_2
X_1334_ net82 net18 net146 VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1265_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand2_1
XFILLER_101_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1196_ _0452_ _0453_ _0469_ _0470_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nand4_1
Xinput3 in1[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_19_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input105_A in2[46] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input70_A in2[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ _0338_ _0340_ _0339_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o21bai_1
X_1883_ _0219_ _0220_ net187 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__or3b_1
X_1952_ clknet_3_2_0_clk _0010_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dfxtp_1
XFILLER_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1317_ net81 net17 net145 VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_16_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1248_ _0533_ _0534_ _0535_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_121_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1179_ _0469_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__nand2_1
XFILLER_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1970__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_34_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1102_ net66 net2 net130 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_91_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1033_ _0321_ _0322_ _0325_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o211ai_4
Xinput50 in1[54] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
X_1797_ net180 _0140_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__xnor2_1
X_1866_ _0201_ _0179_ _0164_ _0190_ _0205_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__a311o_1
XANTENNA__1993__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1935_ _0411_ _0260_ net264 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__o21ai_1
Xinput61 in1[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
Xinput72 in2[16] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_2
Xinput94 in2[36] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_1
Xinput83 in2[26] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input172_A in3[49] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1601__A2 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_A in1[39] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1720_ _0066_ _0068_ _0067_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__o21ai_1
X_1651_ _0902_ _0911_ _0912_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__o21a_1
X_1582_ net266 _0847_ _0848_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__and3_1
X_1016_ net98 net34 net162 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__o21ai_1
X_1849_ _0172_ _0173_ _0188_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__a21oi_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1918_ net264 _0248_ _0249_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and3_1
XANTENNA_clkbuf_3_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input36_X net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1703_ _0949_ _0956_ _0958_ _0961_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__o31a_1
X_1634_ _0865_ _0866_ _0882_ _0883_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nand4_1
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1652__B net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1565_ _0830_ _0831_ net163 VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__o21bai_2
X_1496_ net93 net29 net157 VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__nand3_1
XANTENNA__1933__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout268_A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input135_A in3[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1350_ net83 net19 net147 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nand3_2
X_1281_ _0563_ _0564_ _0566_ net268 VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a31o_1
XFILLER_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0996_ _0288_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nand2_1
XANTENNA__1247__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1617_ _0876_ _0877_ net166 VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a21o_1
XFILLER_115_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1479_ net270 _0751_ _0752_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__nor3_1
X_1548_ _0816_ _0808_ net266 VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_69_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1402_ net85 net21 _0658_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__o211a_1
X_1333_ _0606_ _0614_ _0615_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__a21oi_1
Xinput4 in1[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_1264_ _0542_ _0549_ _0529_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nand3b_2
XFILLER_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1195_ _0455_ _0471_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor2_1
XFILLER_36_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_89_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0979_ net132 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__inv_2
XFILLER_120_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_124_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_98_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input63_A in1[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1870__B1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1882_ net123 net59 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_71_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1951_ clknet_3_1_0_clk _0009_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1316_ net81 net17 VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nand2_1
X_1178_ _0462_ _0468_ _0450_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__nand3b_1
XFILLER_2_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1247_ _0534_ _0533_ net267 VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_121_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1101_ net66 net2 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__nor2_1
X_1032_ net76 net12 _0315_ _0324_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_91_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1934_ _0431_ _0436_ _0394_ _0438_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__o31a_1
Xinput51 in1[55] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_1796_ _0138_ _0139_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__and2b_1
X_1865_ _0189_ _0176_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nor2_1
Xinput40 in1[45] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
Xinput84 in2[27] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_2
Xinput95 in2[37] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_1
Xinput62 in1[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
Xinput73 in2[17] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_42_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input165_A in3[42] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_A in1[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1825__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1650_ _0902_ _0911_ net269 VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a21oi_1
X_1581_ _0837_ _0823_ _0836_ _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__a211o_1
X_1015_ net98 net34 net162 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a21o_1
X_1917_ _0314_ _0320_ _0329_ _0355_ _0385_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a311o_1
X_1848_ _0172_ _0173_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and3_1
X_1779_ _0119_ _0120_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a21o_1
XFILLER_8_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1586__A2 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1702_ _0960_ _0949_ net269 VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a21oi_1
X_1633_ _0865_ _0866_ _0882_ _0883_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__and4_1
X_1564_ net99 net35 VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__and2_1
X_1495_ net93 net29 net157 VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__or3_1
XFILLER_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input128_A in2[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input93_A in2[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1280_ _0552_ _0541_ _0551_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_127_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0995_ _0282_ _0287_ _0280_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__nand3b_1
XPHY_EDGE_ROW_136_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1616_ net102 net38 _0878_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a21o_1
X_1547_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nand2_1
X_1478_ _0725_ _0738_ _0750_ _0724_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_69_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1401_ _0673_ _0674_ net150 VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__o21bai_2
X_1332_ _0606_ _0614_ net265 VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o21ai_1
Xinput5 in1[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__dlymetal6s2s_1
X_1194_ _0482_ _0483_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__nor2_1
XFILLER_36_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1263_ _0542_ _0547_ _0544_ _0525_ _0528_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__o2111ai_2
XFILLER_51_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0978_ net131 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__inv_2
XFILLER_113_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input56_A in1[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1950_ clknet_3_1_0_clk _0008_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dfxtp_1
X_1881_ net123 net59 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_71_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1315_ net81 net17 net145 VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_106_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1177_ _0444_ _0448_ net263 _0467_ _0464_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__o221ai_4
X_1246_ _0518_ _0522_ _0517_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_22_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1377__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput194 net194 VGND VGND VPWR VPWR out[0] sky130_fd_sc_hd__buf_2
XANTENNA_input110_A in2[50] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1031_ net76 net12 net140 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__or3_2
X_1100_ _0356_ _0387_ _0331_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__a31oi_4
XFILLER_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1933_ net264 _0258_ _0259_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and3_1
XFILLER_21_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput52 in1[56] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
X_1795_ net116 net52 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__nand2_1
Xinput30 in1[36] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
X_1864_ _0148_ _0152_ _0202_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a21oi_1
Xinput41 in1[46] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_2
Xinput96 in2[38] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_2
Xinput85 in2[28] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_2
Xinput63 in1[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput74 in2[18] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_2
XFILLER_96_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1229_ _0515_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input158_A in3[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A in1[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1580_ _0739_ net258 _0840_ _0845_ _0838_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a311o_1
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1014_ net98 net34 net162 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__and3_1
X_1847_ _0186_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nand2_1
X_1916_ _0353_ _0354_ _0386_ _0331_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__a22o_1
XFILLER_134_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1778_ _0108_ _0122_ _0123_ _0100_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__o22ai_1
XANTENNA__1504__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1701_ _0739_ _0957_ _0956_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a21o_1
X_1632_ _0893_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__nand2_1
X_1563_ net99 net35 VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__nor2_1
X_1494_ net93 net29 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__or2_1
XFILLER_104_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1396__B net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input86_A in2[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1950__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_X net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0994_ _0277_ _0278_ _0282_ _0286_ _0283_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o221ai_2
XFILLER_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1615_ _0877_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nand2_1
X_1477_ _0723_ _0740_ _0748_ _0749_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__o211a_1
X_1546_ _0809_ _0813_ _0797_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a21bo_1
XFILLER_131_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1973__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input140_A in3[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_127_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1400_ net86 net22 _0676_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a21o_1
X_1331_ _0495_ net261 net260 _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__a31oi_4
Xinput6 in1[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_2
X_1193_ _0481_ _0467_ _0475_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand3_1
XFILLER_36_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1262_ net77 net13 _0544_ _0545_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_101_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0977_ net3 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1529_ net159 _0794_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__o21ai_1
XFILLER_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2001__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input188_A in3[63] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input49_A in1[53] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1584__B net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1880_ _0216_ _0217_ _0218_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__o21a_1
XFILLER_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1314_ _0595_ _0596_ _0597_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1176_ net71 net7 _0464_ _0465_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__o211ai_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1245_ _0531_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_22_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput195 net195 VGND VGND VPWR VPWR out[10] sky130_fd_sc_hd__buf_2
XFILLER_46_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input103_A in2[44] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_76_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1030_ net76 net12 net140 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_21_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1863_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__inv_2
Xinput31 in1[37] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 in1[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1932_ _0436_ _0394_ _0431_ _0435_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__o211ai_1
XFILLER_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput53 in1[57] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
X_1794_ net116 net52 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__nor2_1
Xinput42 in1[47] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_2
Xinput97 in2[39] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_1
Xinput86 in2[29] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput64 in1[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput75 in2[19] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_123_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1228_ net73 net9 _0501_ _0509_ _0514_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_50_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1159_ _0281_ _0284_ _0445_ _0450_ _0447_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__o221ai_2
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1013_ net98 net34 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nand2_1
X_1846_ _0183_ _0184_ net183 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__o21bai_1
X_1777_ _0108_ _0109_ _0096_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__or3_1
X_1915_ _0314_ _0320_ _0329_ _0385_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a31o_1
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input170_A in3[47] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input31_A in1[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1631_ _0891_ _0892_ _0879_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__a21o_1
X_1700_ _0739_ _0957_ _0956_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a21oi_2
X_1493_ _0762_ _0764_ _0765_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a21oi_1
X_1562_ _0827_ _0828_ _0829_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__o21a_1
XFILLER_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1829_ net118 net54 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__and2_1
XFILLER_57_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input79_A in2[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0993_ net69 net5 _0283_ _0285_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__o211ai_1
XFILLER_117_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1614_ net102 net38 net166 VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__o21ai_1
XFILLER_125_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1476_ _0748_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
X_1545_ _0797_ _0809_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__nand3b_2
XFILLER_131_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout266_A _0276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input133_A in3[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1261_ net77 net13 _0545_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__o21ai_1
X_1330_ _0610_ _0539_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__o21ai_2
Xinput7 in1[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dlymetal6s2s_1
X_1192_ _0475_ _0481_ _0467_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__and3_1
XFILLER_36_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0976_ net67 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_109_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1528_ net95 net31 _0795_ _0796_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o211ai_2
X_1459_ _0638_ _0669_ _0696_ _0726_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nor4_1
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout269_X net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_67_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_85_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_94_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1963__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1313_ _0596_ _0595_ net268 VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1244_ _0524_ _0530_ _0512_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nand3b_1
X_1175_ _0463_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_2
XFILLER_24_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput196 net196 VGND VGND VPWR VPWR out[11] sky130_fd_sc_hd__buf_2
XFILLER_46_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_3_7_0_clk_X clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in1[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1986__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput54 in1[58] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
X_1862_ _0145_ _0163_ _0165_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__or4bb_1
X_1793_ _0136_ _0137_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__nor2_1
Xinput43 in1[48] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
Xinput32 in1[38] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
Xinput21 in1[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
X_1931_ _0435_ _0256_ _0431_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__a21o_1
Xinput10 in1[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
Xinput87 in2[2] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
Xinput65 in2[0] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
Xinput76 in2[1] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_2
Xinput98 in2[3] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_1
XFILLER_96_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1158_ net70 net6 _0447_ _0449_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__o211ai_1
X_1227_ _0509_ _0514_ _0502_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__and3_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1089_ _0374_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nor2_1
XFILLER_113_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1012_ net98 net34 net162 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__or3_1
X_1914_ _0330_ _0245_ _0246_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__o21a_1
X_1845_ _0183_ _0184_ net183 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__or3b_1
X_1776_ _0093_ _0109_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__nor2_1
XFILLER_118_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input163_A in3[40] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input24_A in1[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1630_ _0888_ _0889_ _0879_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__o211ai_1
X_1492_ _0762_ _0764_ net266 VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__o21ai_1
X_1561_ _0828_ _0827_ net270 VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__a21oi_1
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1828_ net118 net54 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__nor2_1
X_1759_ net113 net49 _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a21oi_2
XFILLER_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0992_ _0281_ _0284_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nor2_1
XFILLER_132_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1613_ net102 net38 VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__nand2_1
X_1544_ net96 net32 _0810_ _0811_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_105_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1475_ _0742_ _0747_ _0718_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nand3b_1
XFILLER_5_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_114_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_123_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input126_A in2[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_132_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input91_A in2[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 in1[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
X_1191_ _0475_ _0481_ _0467_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21oi_1
X_1260_ _0543_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__nand2_1
X_0975_ net191 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__inv_2
XFILLER_126_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1561__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1527_ net95 net31 _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1389_ _0654_ _0651_ _0637_ _0636_ _0653_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__o2111a_1
X_1458_ _0638_ _0669_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor2_1
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1312_ _0577_ _0581_ _0576_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__o21a_1
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1174_ net71 net7 net135 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__o21ai_1
X_1243_ _0524_ _0529_ _0526_ _0513_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__o211ai_2
XFILLER_32_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1534__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput197 net197 VGND VGND VPWR VPWR out[12] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input193_A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input54_A in1[58] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1930_ _0394_ _0436_ _0257_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__a21oi_1
Xinput55 in1[59] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput33 in1[39] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
X_1861_ _0178_ _0191_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__nor2_1
X_1792_ _0119_ _0126_ _0135_ net269 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a31o_1
Xinput44 in1[49] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput88 in2[30] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_2
Xinput77 in2[20] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_2
Xinput22 in1[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_2
Xinput66 in2[10] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_2
Xinput11 in1[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput99 in2[40] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_82_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1157_ _0274_ _0446_ _0444_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__a21oi_1
X_1226_ _0509_ _0514_ _0502_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21o_1
XFILLER_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1088_ _0379_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nand2_1
XFILLER_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1953__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1011_ _0303_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand2b_1
X_1913_ _0330_ _0245_ net267 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a21oi_1
X_1844_ net119 net55 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nand2_1
X_1775_ _0119_ _0120_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__and2_1
XFILLER_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1209_ net73 net9 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nand2_1
XFILLER_111_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1976__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input156_A in3[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in1[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1560_ _0816_ _0808_ _0814_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__o21ai_1
X_1491_ _0725_ _0750_ _0738_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__o31a_1
XFILLER_3_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1999__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1827_ net117 net53 _0161_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__a21boi_1
X_1758_ net113 net49 net177 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__o21ai_1
X_1689_ net106 net42 _0944_ _0946_ _0932_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a221o_1
XFILLER_1_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2004__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_A in1[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0991_ net69 net5 net133 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a21o_1
XFILLER_132_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1612_ net102 net38 VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__or2_1
X_1474_ _0742_ _0746_ _0744_ _0719_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o211ai_2
X_1543_ net96 net32 _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o21a_1
XFILLER_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input119_A in2[59] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input84_A in2[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1190_ net72 net8 _0477_ _0478_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__o211ai_2
Xinput9 in1[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
XFILLER_44_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0974_ net190 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__inv_2
X_1526_ net95 net31 net159 VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__a21o_1
X_1457_ _0728_ _0729_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o21ai_1
X_1388_ _0652_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nor2_1
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1311_ _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nand2_1
X_1173_ net71 net7 net135 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a21o_1
XFILLER_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ net75 net11 _0526_ _0527_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__o211ai_1
XFILLER_101_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1509_ _0763_ _0777_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__o21ai_1
Xoutput198 net198 VGND VGND VPWR VPWR out[13] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire259 _0778_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_1
XFILLER_127_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input47_A in1[51] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input186_A in3[61] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1860_ _0198_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__and2b_1
XFILLER_14_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1791_ _0119_ _0126_ _0135_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a21oi_1
Xinput89 in2[31] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 in1[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput67 in2[11] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
Xinput12 in1[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_2
Xinput45 in1[4] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_2
Xinput34 in1[3] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput56 in1[5] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_2
Xinput78 in2[21] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_2
XFILLER_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1156_ net70 net6 net134 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__a21o_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1225_ net74 net10 _0510_ _0511_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__o211ai_4
X_1087_ _0358_ _0360_ _0342_ _0375_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o211ai_2
X_1989_ clknet_3_7_0_clk _0047_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dfxtp_1
XFILLER_20_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input101_A in2[42] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__0982__A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1010_ net87 net23 net151 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__o21ai_1
X_1843_ net119 net55 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__and2_1
X_1912_ _0314_ _0386_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__and2_1
X_1774_ _0115_ _0118_ _0103_ _0106_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__a211o_1
X_1208_ _0497_ _0275_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1139_ net127 net63 net191 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nor3_1
XFILLER_138_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input149_A in3[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1490_ _0723_ _0748_ _0749_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21boi_1
XFILLER_3_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1826_ _0144_ _0156_ _0166_ _0168_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__o31a_1
X_1757_ _0102_ _0103_ net177 VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__o21bai_1
X_1688_ _0942_ _0945_ _0929_ _0932_ _0944_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__o221ai_2
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1943__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1611_ net101 net37 _0863_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a21bo_1
X_0990_ net69 net5 net133 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a21oi_1
X_1473_ _0746_ _0744_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__nand2_1
X_1542_ net96 net32 net160 VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1966__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1809_ _0149_ _0151_ _0150_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__nand3b_1
XFILLER_116_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1398__A2 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_46_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1989__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input77_A in2[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0973_ net189 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_1525_ net95 net31 net159 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand3_1
X_1387_ _0651_ _0654_ _0637_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__o21a_1
X_1456_ _0695_ _0697_ _0710_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a31oi_1
XANTENNA_fanout264_A net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input131_A in3[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1310_ _0585_ _0590_ _0573_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand3_1
X_1241_ _0525_ _0528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_72_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1172_ net71 net7 net135 VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_62_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1508_ _0761_ _0771_ _0773_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__o21a_1
X_1439_ _0701_ _0703_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_2
Xoutput199 net199 VGND VGND VPWR VPWR out[14] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_120_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout267_X net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input179_A in3[55] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1790_ _0132_ _0133_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__or2_1
Xinput13 in1[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xinput57 in1[60] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput46 in1[50] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
Xinput35 in1[40] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
Xinput24 in1[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_2
Xinput79 in2[22] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput68 in2[12] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_1
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1516__A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1224_ net74 net10 _0511_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_90_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1155_ net70 net6 net134 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a21oi_1
X_1086_ _0358_ _0360_ _0342_ _0375_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__o211a_1
X_1988_ clknet_3_7_0_clk _0046_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dfxtp_1
XFILLER_20_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1957__Q net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1842_ net119 net55 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nor2_1
X_1773_ _0114_ _0116_ _0103_ _0106_ _0115_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o221ai_4
X_1911_ net264 _0329_ _0244_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and3_1
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1334__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1207_ net73 net9 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__nor2_1
X_1138_ _0421_ _0423_ _0269_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o21ai_1
X_1069_ net126 net62 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand2_1
XFILLER_138_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1655__A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1756_ net113 net49 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__and2_1
X_1825_ _0167_ _0166_ net269 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a21oi_1
X_1687_ net107 net43 _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a21o_1
XFILLER_57_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1511__B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input161_A in3[39] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input22_A in1[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1610_ _0867_ _0871_ _0874_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__o21a_1
X_1472_ _0743_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__nand2_2
X_1541_ net96 net32 net160 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nand3_1
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1628__A1 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1808_ _0149_ _0151_ _0150_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__and3b_1
XFILLER_116_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1739_ _0085_ _0086_ _0087_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o21a_1
XFILLER_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_101_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input25_X net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_118_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0972_ net61 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__inv_2
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1524_ net95 net31 VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__or2_1
X_1455_ _0694_ _0707_ _0708_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a21oi_1
X_1386_ _0663_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input124_A in2[63] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1956__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1171_ net71 net7 VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__nand2_1
X_1240_ net75 net11 net139 VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1507_ _0725_ _0750_ _0762_ _0774_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__nor4_1
XFILLER_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1369_ _0646_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__nand2_1
X_1438_ _0711_ _0712_ _0713_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_120_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput25 in1[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_2
Xinput36 in1[41] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
Xinput14 in1[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput47 in1[51] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
Xinput58 in1[61] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput69 in2[13] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlymetal6s2s_1
X_1154_ net70 net6 net134 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nand3_1
X_1223_ net74 net10 _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_90_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1085_ _0343_ _0376_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__nand3_1
X_1987_ clknet_3_7_0_clk _0045_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dfxtp_1
XFILLER_87_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input191_A in3[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input52_A in1[56] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1424__B net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1910_ _0323_ _0325_ _0326_ _0328_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__a31o_1
X_1772_ net114 net50 _0116_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a21o_1
X_1841_ net266 _0181_ _0182_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and3_1
XFILLER_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1137_ _0426_ _0430_ _0429_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__o21ai_2
X_1206_ _0485_ _0492_ _0494_ _0496_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__o31a_1
XFILLER_27_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1068_ net126 net62 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and2_1
XFILLER_124_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1655__A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1755_ net113 net49 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
X_1824_ _0145_ _0154_ _0143_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o21ai_1
X_1686_ net107 net43 net171 VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input154_A in3[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in1[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1540_ net96 net32 net160 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__or3_1
XFILLER_74_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1471_ net91 net27 net155 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1628__A2 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1807_ _0108_ _0122_ _0135_ _0121_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__or4b_1
XFILLER_108_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1738_ _0086_ _0085_ net269 VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21oi_1
X_1669_ net106 net42 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input7_A in1[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0971_ net125 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
X_1523_ _0784_ _0786_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nand2_1
X_1454_ _0639_ _0668_ _0667_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a21oi_1
XANTENNA__1623__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1385_ _0661_ _0662_ _0649_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_65_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1234__B1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input117_A in2[57] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input82_A in2[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ net71 net7 net135 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_62_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_120_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1506_ _0760_ _0761_ _0772_ _0773_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nand4_1
X_1437_ _0711_ _0712_ net265 VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_93_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1368_ net84 net20 net148 VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__o21ai_2
X_1299_ net80 net16 VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_120_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput48 in1[52] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput26 in1[32] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_2
Xinput37 in1[42] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput59 in1[62] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput15 in1[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1153_ net70 net6 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__nand2_1
X_1084_ _0265_ _0266_ _0360_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__o211ai_1
X_1222_ net74 net10 net138 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a21o_1
X_1986_ clknet_3_7_0_clk _0044_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1437__B1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1946__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input45_A in1[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input184_A in3[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1667__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1840_ _0179_ _0156_ _0176_ _0177_ _0164_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o2111ai_2
XANTENNA__1440__B net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1771_ net114 net50 _0116_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a21oi_1
XANTENNA__1439__Y _0714_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1969__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1136_ _0405_ _0427_ _0425_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__o21bai_2
X_1205_ _0495_ _0485_ net267 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__a21oi_1
X_1067_ _0265_ _0266_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21a_1
X_1969_ clknet_3_6_0_clk _0027_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dfxtp_1
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1823_ _0164_ _0165_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__and2_1
X_1754_ _0096_ _0100_ _0101_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1685_ _0941_ _0942_ net171 VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__o21bai_1
XANTENNA__1879__B1 net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1119_ _0291_ _0272_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input147_A in3[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1470_ net91 net27 net155 VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand3_1
XFILLER_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ _0119_ _0133_ _0132_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__o21ba_1
XFILLER_116_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1737_ _0965_ _0070_ _0075_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21ai_1
X_1599_ net101 net37 _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a21o_1
X_1668_ _0921_ _0926_ _0928_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1555__A2 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1904__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1522_ _0781_ _0790_ _0792_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__o21ba_1
X_1453_ _0665_ _0684_ _0695_ _0710_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__nand4b_1
X_1384_ _0661_ _0662_ _0649_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a21o_1
X_2005_ clknet_3_0_0_clk _0063_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_42_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_123_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input75_A in2[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input30_X net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1505_ _0774_ _0775_ _0776_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__o21a_1
X_1367_ net84 net20 net148 VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__and3_1
X_1436_ _0698_ _0693_ _0694_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_93_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1298_ _0577_ _0581_ _0582_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__a21oi_1
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 in1[53] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
Xinput38 in1[43] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput27 in1[33] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput16 in1[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_2
XFILLER_28_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1221_ net74 net10 net138 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__nand3_1
XFILLER_93_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1152_ net70 net6 net134 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__nor3_1
X_1083_ _0357_ _0267_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nand2_1
X_1985_ clknet_3_7_0_clk _0043_ VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dfxtp_1
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1419_ _0663_ _0664_ _0681_ _0683_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nand4_2
XFILLER_113_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout265_X net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input177_A in3[53] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_A in1[43] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1770_ net114 net50 net178 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__o21ai_2
XFILLER_103_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1204_ _0491_ _0394_ _0493_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__o21ai_4
X_1135_ _0402_ _0404_ _0425_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__o211ai_2
X_1066_ net125 net61 net189 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__o21ai_2
X_1899_ net60 net188 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xnor2_1
X_1968_ clknet_3_6_0_clk _0026_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dfxtp_1
XFILLER_108_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1822_ _0158_ _0161_ _0162_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__nand3_1
X_1753_ _0100_ _0096_ net269 VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a21o_1
XFILLER_90_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1684_ net107 net43 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__nand2_1
XFILLER_72_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1118_ net131 _0292_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand2_1
X_1049_ net120 net56 _0341_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_79_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_88_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1805_ _0082_ _0097_ _0098_ _0146_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a31oi_1
XFILLER_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1736_ _0082_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and2_1
XFILLER_131_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1598_ net101 net37 net165 VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__o21ai_1
X_1667_ _0926_ _0921_ net270 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__a21oi_1
XFILLER_121_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input20_A in1[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1521_ _0781_ _0788_ _0789_ net270 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a31o_1
X_1383_ net85 net21 net149 VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__or3_1
X_1452_ _0696_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nor2_1
X_2004_ clknet_3_0_0_clk _0062_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dfxtp_1
XFILLER_35_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1719_ net110 net46 _0068_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_100_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input68_A in2[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1449__C1 _0714_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1504_ _0775_ _0774_ net270 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a21oi_1
X_1366_ net84 net20 VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__nand2_1
X_1435_ _0707_ _0709_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__nand2_1
X_1297_ _0577_ _0581_ net265 VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_21_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input122_A in2[61] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput39 in1[44] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
Xinput28 in1[34] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA__1906__B1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput17 in1[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
X_1151_ net70 net6 VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nor2_1
X_1220_ net74 net10 net138 VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__or3_2
XFILLER_93_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1082_ net189 _0358_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nand2_1
X_1984_ clknet_3_5_0_clk _0042_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dfxtp_1
XFILLER_9_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1349_ net83 net19 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_1
X_1418_ _0693_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__and2_1
XANTENNA__1428__A2 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1992__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1600__A2 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_108_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1134_ _0401_ _0402_ net192 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__o21bai_1
X_1203_ _0490_ _0440_ _0489_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21ai_2
X_1065_ net125 net61 net189 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_117_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1898_ net123 net59 _0221_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a21bo_1
X_1967_ clknet_3_6_0_clk _0025_ VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_126_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_135_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_A in1[54] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1337__A1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1821_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
X_1752_ _0099_ _0959_ _0097_ _0098_ _0082_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__o2111a_1
X_1683_ net107 net43 VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__and2_1
XANTENNA__1642__B net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1117_ _0408_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1048_ _0338_ _0340_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nor2_1
XFILLER_135_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1567__A1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input98_A in2[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1918__A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1804_ _0956_ _0958_ _0147_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o21bai_1
X_1735_ net110 net46 _0078_ _0081_ _0069_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__a221o_1
X_1666_ _0926_ _0921_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__nand2_1
XFILLER_131_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1597_ _0860_ _0861_ net165 VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__o21bai_2
XANTENNA__1653__A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1563__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input152_A in3[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input13_A in1[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1520_ _0781_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nand2_1
XFILLER_72_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1382_ net85 net21 _0658_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__o211ai_2
X_1451_ _0693_ _0694_ _0707_ _0709_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__nand4_1
X_2003_ clknet_3_2_0_clk _0061_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dfxtp_1
X_1718_ net110 net46 net174 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o21ai_1
X_1649_ _0909_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__nor2_1
XFILLER_116_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_A in1[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1949__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1503_ _0762_ _0764_ _0761_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__o21a_1
X_1365_ net84 net20 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__and2_1
X_1434_ _0706_ _0708_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__nor2_1
X_1296_ _0552_ _0565_ _0541_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__o31a_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input115_A in2[55] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1841__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput18 in1[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input80_A in2[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput29 in1[35] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_96_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1150_ _0290_ _0442_ _0443_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__o21a_1
XFILLER_35_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1081_ _0357_ _0358_ _0267_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__o21ai_1
X_1983_ clknet_3_5_0_clk _0041_ VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dfxtp_1
X_1417_ _0686_ _0692_ _0677_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nand3b_1
X_1348_ net83 net19 net147 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nor3_1
X_1279_ _0563_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nand2_1
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1133_ net128 net64 net192 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nor3_1
X_1202_ _0490_ _0440_ _0489_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__o21a_1
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1064_ net125 net61 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and2_2
X_1966_ clknet_3_6_0_clk _0024_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dfxtp_1
X_1897_ _0226_ _0232_ _0234_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__o21a_1
XFILLER_124_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout270_X net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input182_A in3[58] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_A in1[48] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1820_ _0161_ _0162_ _0158_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__a21oi_1
XFILLER_128_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1751_ _0949_ _0969_ _0071_ _0085_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__nand4_1
X_1682_ net107 net43 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__nor2_1
XFILLER_80_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1116_ _0398_ _0406_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__o21bai_1
X_1047_ net120 net56 net184 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a21o_1
XFILLER_80_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1949_ clknet_3_1_0_clk _0007_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0099_ _0146_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1734_ net110 net46 _0078_ _0081_ _0069_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__a221oi_1
X_1596_ net101 net37 VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and2_1
X_1665_ _0910_ _0925_ _0924_ _0900_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__o22ai_2
XFILLER_105_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1653__B net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input145_A in3[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1450_ _0722_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_109_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1381_ net85 net21 net149 VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_132_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2002_ clknet_3_0_0_clk _0060_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dfxtp_1
XFILLER_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1717_ _0065_ _0066_ net174 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__o21bai_1
XFILLER_104_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1648_ net168 _0905_ _0907_ _0904_ _0890_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a221oi_4
X_1579_ _0739_ _0842_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a21oi_2
XFILLER_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1502_ _0772_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nand2_1
X_1433_ _0704_ _0705_ _0691_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__a21o_1
X_1364_ net84 net20 net148 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__nor3_1
X_1295_ _0563_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__nand2_1
XFILLER_23_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input108_A in2[49] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 in1[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input73_A in2[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1080_ _0367_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand2_1
X_1982_ clknet_3_5_0_clk _0040_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dfxtp_1
XANTENNA__1479__A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1416_ _0686_ _0691_ _0688_ _0675_ _0676_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__o2111ai_2
X_1347_ _0626_ _0627_ _0628_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_81_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1278_ _0555_ _0562_ _0547_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nand3b_1
XFILLER_138_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_6_0_clk_X clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1521__B1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1201_ _0388_ _0392_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a21oi_2
XFILLER_92_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1132_ net128 net64 net192 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and3_1
X_1063_ net125 net61 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nor2_1
X_1965_ clknet_3_6_0_clk _0023_ VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dfxtp_1
X_1896_ _0232_ _0226_ net271 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a21oi_1
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input175_A in3[51] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1582__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input36_A in1[41] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1750_ _0965_ _0070_ _0083_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__or3_1
XFILLER_95_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1681_ _0939_ _0940_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__nor2_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1115_ _0399_ _0403_ _0404_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nand3_1
X_1046_ net120 net56 net184 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a21oi_1
X_1879_ _0217_ _0216_ net271 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1948_ clknet_3_1_0_clk _0006_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dfxtp_1
XFILLER_135_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input39_X net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkload1_A clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1802_ _0096_ _0110_ _0121_ _0134_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__nand4b_1
X_1733_ _0077_ _0079_ _0066_ _0069_ _0078_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o221ai_4
XPHY_EDGE_ROW_75_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1595_ net101 net37 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__nor2_1
X_1664_ _0879_ _0891_ _0892_ _0909_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a31oi_1
XPHY_EDGE_ROW_84_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_135_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_93_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1029_ net65 net1 _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a21o_1
XFILLER_107_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input138_A in3[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1972__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1380_ net85 net21 _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__o21a_1
XANTENNA__1400__A2 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2001_ clknet_3_0_0_clk _0059_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_132_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1716_ net110 net46 VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__and2_1
Xclkbuf_3_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1647_ _0905_ _0906_ _0908_ _0890_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o211a_1
XANTENNA__1680__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1578_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_56_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2000__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1501_ _0754_ _0755_ _0767_ _0770_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__o211ai_2
X_1363_ net84 net20 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nor2_1
X_1432_ _0704_ _0705_ _0691_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a21oi_1
XFILLER_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1294_ _0551_ _0564_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nand2_1
XFILLER_23_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_2_0_clk_X clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input66_A in2[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1981_ clknet_3_5_0_clk _0039_ VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dfxtp_1
XFILLER_87_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1415_ _0691_ _0688_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nand2_1
X_1346_ _0627_ _0626_ net268 VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_81_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1277_ _0555_ _0560_ _0557_ _0548_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__o211ai_2
XFILLER_132_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input120_A in2[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1200_ _0420_ _0437_ _0456_ _0486_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__nand4b_4
XFILLER_33_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1131_ _0269_ _0422_ _0423_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a21oi_2
X_1062_ _0349_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor2_1
X_1895_ _0231_ _0229_ _0227_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a21oi_1
X_1964_ clknet_3_4_0_clk _0022_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dfxtp_1
XFILLER_83_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1329_ _0580_ _0608_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__o21ba_1
XFILLER_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input168_A in3[45] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_113_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input29_A in1[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_122_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1680_ net266 _0938_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_131_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1114_ net66 net2 net130 _0405_ _0400_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__o311ai_4
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1045_ net120 net56 net184 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nor3_1
X_1878_ _0198_ _0207_ _0199_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1947_ clknet_3_0_0_clk _0005_ VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dfxtp_1
XFILLER_135_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1801_ _0142_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__or2_2
X_1732_ net111 net47 _0079_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__a21o_1
X_1663_ _0909_ _0910_ _0895_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__or3_1
X_1594_ _0855_ _0856_ _0858_ _0859_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_135_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1397__B net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1028_ net65 net1 net129 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o21a_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input96_A in2[38] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2000_ clknet_3_2_0_clk _0058_ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_132_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1715_ net110 net46 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nor2_1
X_1646_ _0903_ _0905_ net168 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o21bai_1
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1577_ _0780_ _0840_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21oi_2
XFILLER_41_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input150_A in3[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input11_A in1[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input99_X net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1500_ _0767_ _0770_ _0757_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a21o_1
XANTENNA__1781__A net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1362_ net265 _0641_ _0642_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and3_1
X_1431_ net88 net24 _0689_ _0704_ _0705_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__o2111ai_4
X_1293_ _0550_ _0551_ _0563_ _0564_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__and4_1
Xinput190 in3[7] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_61_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1629_ _0887_ _0888_ net167 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__o21bai_1
XFILLER_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1962__CLK clknet_3_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input3_A in1[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1585__B net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input59_A in1[62] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_output215_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1980_ clknet_3_5_0_clk _0038_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dfxtp_1
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1985__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1414_ _0687_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand2_2
X_1345_ _0606_ _0614_ _0605_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__o21ai_1
X_1276_ net78 net14 _0557_ _0558_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__o211ai_1
XFILLER_3_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input113_A in2[53] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1588__A2 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1130_ net127 net63 net191 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__o21ai_1
X_1061_ _0353_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__nand2_1
X_1894_ _0230_ _0207_ _0228_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__o21bai_1
X_1963_ clknet_3_4_0_clk _0021_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dfxtp_1
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1328_ _0576_ _0592_ _0594_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o21ai_1
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1259_ net77 net13 net141 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1113_ net66 net2 net130 _0405_ _0400_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__o311a_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1044_ net120 net56 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__nor2_1
XFILLER_134_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1877_ _0214_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__nor2_1
XFILLER_119_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1946_ clknet_3_0_0_clk _0004_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_138_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input180_A in3[56] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input41_A in1[46] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1800_ _0143_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
XFILLER_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1731_ net111 net47 _0079_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a21oi_1
X_1662_ _0909_ _0910_ _0895_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nor3_1
X_1593_ _0858_ _0857_ net270 VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_135_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1027_ net65 net1 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__and2_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1929_ _0436_ _0394_ net264 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_36_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input89_A in2[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1149__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1714_ _0969_ _0970_ _0064_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__o21a_1
X_1645_ net104 net40 _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a21boi_2
X_1576_ _0825_ _0814_ _0807_ _0839_ _0824_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__o221ai_2
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input143_A in3[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1430_ _0700_ _0703_ _0691_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__o211a_1
Xinput180 in3[56] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_1
X_1361_ _0636_ _0637_ _0640_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand3_1
X_1292_ _0575_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__nand2_1
Xinput191 in3[8] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_61_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1628_ net103 net39 _0889_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a21o_1
X_1559_ _0824_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__and2_1
XFILLER_100_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1413_ net88 net24 net152 VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__o21ai_1
XFILLER_95_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1344_ _0624_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__and2_1
X_1275_ net78 net14 _0558_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input106_A in2[47] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input71_A in2[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ net173 _0333_ _0311_ _0352_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__o211ai_4
X_1962_ clknet_3_4_0_clk _0020_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1893_ _0206_ _0204_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o21bai_1
XFILLER_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1952__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1189_ _0476_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nand2_1
X_1258_ net77 net13 net141 VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21o_1
X_1327_ _0578_ _0607_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5_0_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1975__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_36_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1112_ net66 net2 net130 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nor3_1
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1043_ net120 net56 net184 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nand3_1
XFILLER_119_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1945_ clknet_3_0_0_clk _0003_ VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dfxtp_1
X_1876_ net121 net57 _0212_ _0213_ _0196_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__a221oi_2
XFILLER_119_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1998__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input173_A in3[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2003__CLK clknet_3_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_A in1[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1730_ net111 net47 net175 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o21ai_2
X_1661_ _0919_ _0920_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
X_1592_ _0835_ _0848_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__and2_1
XFILLER_53_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1026_ net76 net12 _0315_ _0317_ _0318_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__o2111ai_4
XFILLER_38_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1859_ _0185_ _0186_ _0196_ _0197_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_62_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1928_ _0388_ _0392_ _0436_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a21o_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1713_ _0970_ _0969_ net269 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1644_ net104 net40 net168 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o21ai_1
X_1575_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__inv_2
XFILLER_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout269_A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1009_ net87 net23 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__and2_1
XFILLER_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input136_A in3[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1360_ _0636_ _0637_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21o_1
XFILLER_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput181 in3[57] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_1
Xinput170 in3[47] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_1
X_1291_ _0568_ _0574_ _0560_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand3b_2
Xinput192 in3[9] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1627_ net103 net39 _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__a21bo_1
XFILLER_100_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1558_ _0820_ _0823_ _0812_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a21o_1
X_1489_ _0760_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nand2_1
XANTENNA__1297__B1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1412_ net88 net24 net152 VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a21o_1
X_1343_ _0616_ _0622_ _0602_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand3b_1
XFILLER_95_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1274_ _0556_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nand2_1
X_0989_ net69 net5 net133 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input64_A in1[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1892_ _0214_ _0215_ _0200_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__or3b_1
X_1961_ clknet_3_4_0_clk _0019_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dfxtp_1
XFILLER_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1326_ _0552_ _0565_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nor3_1
XFILLER_83_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1188_ net72 net8 net136 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__o21ai_1
X_1257_ net77 net13 net141 VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__nand3_1
XFILLER_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1111_ _0403_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nand2_2
XFILLER_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1042_ _0332_ _0334_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nor2_1
X_1875_ _0195_ _0196_ _0212_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__o211a_1
XFILLER_9_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1944_ clknet_3_0_0_clk _0002_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dfxtp_1
XFILLER_134_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1309_ _0573_ _0586_ _0591_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand3b_1
XFILLER_44_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input166_A in3[43] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input27_A in1[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1942__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1660_ _0919_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__and2_1
X_1591_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__or2_1
XFILLER_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_53_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1025_ _0315_ _0316_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__a22oi_4
X_1858_ _0196_ _0197_ _0185_ _0186_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__o211a_1
X_1927_ _0374_ _0254_ _0255_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__o21a_1
XFILLER_130_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1789_ _0132_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__nor2_1
XANTENNA__1965__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1609__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1712_ _0960_ _0949_ _0947_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__a21bo_1
X_1643_ net104 net40 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__and2_1
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1988__CLK clknet_3_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1574_ net258 _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nand2_1
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1008_ net87 net23 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__nor2_1
XANTENNA_clkbuf_3_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input129_A in3[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input94_A in2[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput182 in3[58] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_1
Xinput171 in3[48] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_90_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput160 in3[38] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_1
X_1290_ _0568_ _0573_ _0570_ _0561_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_46_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput193 rst VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_1
X_1626_ net103 net39 net167 VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_129_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1557_ _0820_ _0823_ _0812_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a21oi_1
X_1488_ _0754_ _0756_ _0746_ _0758_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_138_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1515__A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1411_ net88 net24 net152 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nand3_1
X_1342_ _0616_ _0620_ _0618_ _0603_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__o211ai_1
X_1273_ net78 net14 net142 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0988_ net69 net5 net133 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__nor3_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1609_ _0871_ _0867_ net269 VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a21oi_1
XFILLER_103_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input1_A in1[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input57_A in1[60] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1891_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_1960_ clknet_3_3_0_clk _0018_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dfxtp_1
XFILLER_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1325_ _0575_ _0576_ _0593_ _0594_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nand4_1
X_1256_ net77 net13 VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__nand2_1
XFILLER_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1187_ net72 net8 net136 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a21o_1
XFILLER_137_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput250 net250 VGND VGND VPWR VPWR out[60] sky130_fd_sc_hd__buf_2
XFILLER_58_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input111_A in2[51] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1110_ net128 net64 net192 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o21ai_2
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1041_ net109 net45 net173 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__a21o_1
X_1874_ _0210_ _0211_ net186 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__o21bai_1
XFILLER_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1943_ clknet_3_0_0_clk _0001_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_138_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1308_ _0585_ _0590_ _0573_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__a21oi_1
XFILLER_28_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1239_ net75 net11 net139 VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a21o_1
XFILLER_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input159_A in3[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1590_ _0849_ _0850_ _0854_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__and3_1
XFILLER_50_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1024_ _0302_ _0303_ net151 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__o21bai_4
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1627__A1 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1788_ net114 net50 _0130_ _0131_ _0117_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a221oi_2
X_1857_ _0194_ _0195_ net185 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o21ba_1
X_1926_ _0254_ _0374_ net267 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a21oi_1
XFILLER_130_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_110_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1711_ _0967_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__nor2_1
X_1642_ net104 net40 net168 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__or3_1
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1573_ _0805_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nor2_1
X_1007_ _0299_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nand2_1
XFILLER_25_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1909_ net264 _0327_ _0243_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__and3_1
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap260 _0609_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_1
XFILLER_106_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input87_A in2[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_23_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput183 in3[59] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_1
Xinput172 in3[49] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_1
Xinput161 in3[39] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_1
Xinput150 in3[29] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_46_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1955__CLK clknet_3_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1625_ net103 net39 VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__and2_1
X_1556_ net96 net32 _0811_ _0820_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__o2111ai_4
XFILLER_100_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1487_ _0758_ _0759_ _0746_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_20_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input141_A in3[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1410_ net88 net24 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__nand2_1
XFILLER_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1341_ _0616_ _0620_ _0618_ _0603_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__o211a_1
X_1272_ net78 net14 net142 VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21o_1
XFILLER_3_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1920__B1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0987_ net69 net5 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nor2_1
X_1608_ _0867_ _0871_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or2_1
X_1539_ _0800_ _0806_ _0802_ _0791_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_103_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1442__A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input189_A in3[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1890_ _0215_ _0199_ _0214_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o21bai_1
XFILLER_53_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1324_ _0577_ _0595_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nor2_1
X_1186_ net72 net8 net136 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1255_ net77 net13 net141 VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__nor3_1
XFILLER_137_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput240 net240 VGND VGND VPWR VPWR out[51] sky130_fd_sc_hd__buf_2
Xoutput251 net251 VGND VGND VPWR VPWR out[61] sky130_fd_sc_hd__buf_2
XFILLER_59_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input104_A in2[45] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1958__Q net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1040_ net109 net45 net173 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a21oi_1
XFILLER_64_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1942_ clknet_3_0_0_clk _0000_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1873_ _0210_ _0211_ net186 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__or3b_1
XANTENNA__1335__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1645__A2 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1307_ _0583_ _0587_ _0584_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__o21bai_1
X_1169_ net264 _0460_ _0461_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_32_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1238_ net75 net11 net139 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nand3_1
XFILLER_60_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1627__A2 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1023_ net87 net23 _0304_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a21o_2
X_1925_ _0382_ _0252_ _0381_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o21a_1
X_1787_ _0114_ _0117_ _0130_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o211a_1
X_1856_ _0194_ _0195_ net185 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nor3b_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1512__B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input171_A in3[48] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input32_A in1[38] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1710_ _0962_ _0966_ _0943_ _0946_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o211a_1
X_1641_ net104 net40 VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nor2_1
X_1572_ _0814_ _0815_ _0824_ _0826_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nand4_1
XFILLER_61_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1006_ _0294_ _0296_ _0298_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand3b_1
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1839_ _0178_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
X_1908_ net65 net1 _0325_ _0326_ _0322_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a221o_1
XFILLER_106_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput151 in3[2] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
Xinput140 in3[1] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_1
Xinput162 in3[3] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_1
Xinput173 in3[4] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
Xinput184 in3[5] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_1
X_1624_ net103 net39 VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1555_ net97 net33 _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__a21o_2
X_1486_ net92 net28 _0756_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_6_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout267_A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input134_A in3[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ _0620_ _0618_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__nand2_1
XFILLER_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1271_ net78 net14 net142 VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nand3_1
XFILLER_3_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0986_ _0277_ _0278_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__nor2_1
X_1469_ net91 net27 VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__nand2_1
X_1607_ _0855_ _0870_ _0869_ _0846_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__o22ai_2
X_1538_ _0800_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_1
Xclkbuf_3_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_128_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1945__CLK clknet_3_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1323_ _0604_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nand2_1
XFILLER_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1185_ net72 net8 VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand2_1
X_1254_ _0495_ _0537_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_96_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput252 net252 VGND VGND VPWR VPWR out[62] sky130_fd_sc_hd__buf_2
Xoutput241 net241 VGND VGND VPWR VPWR out[52] sky130_fd_sc_hd__buf_2
Xoutput230 net230 VGND VGND VPWR VPWR out[42] sky130_fd_sc_hd__buf_2
XANTENNA__1896__B1 net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1968__CLK clknet_3_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1425__B net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input62_A in1[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1872_ net122 net58 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__and2_1
X_1941_ _0301_ _0441_ _0264_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__o21a_1
XFILLER_127_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1306_ net80 net16 _0586_ _0588_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__o211ai_1
XFILLER_64_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1168_ _0457_ _0459_ _0455_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a21o_1
X_1099_ _0384_ _0390_ _0391_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__o21ai_1
X_1237_ net75 net11 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__nand2_1
XFILLER_133_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1022_ net76 net12 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__or2_1
XFILLER_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1855_ net121 net57 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__and2_1
XFILLER_61_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1924_ _0382_ _0252_ _0253_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__a21boi_1
X_1786_ _0127_ _0128_ net179 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input164_A in3[41] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1554__A2 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input25_A in1[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1640_ _0895_ _0900_ _0893_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__o21ai_1
X_1571_ _0823_ _0837_ _0836_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_131_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1005_ _0297_ _0294_ _0295_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__nand3_1
XFILLER_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1838_ _0179_ _0156_ _0164_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o21ai_1
X_1907_ _0323_ _0241_ _0242_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__a21oi_1
X_1769_ _0113_ _0114_ net178 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__o21bai_2
XFILLER_103_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap262 _0629_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_1
XFILLER_82_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput185 in3[60] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_1
Xinput163 in3[40] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput174 in3[50] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput152 in3[30] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_1
Xinput130 in3[10] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_2
Xinput141 in3[20] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_1
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1624__A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1623_ net266 _0885_ _0886_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__and3_1
X_1554_ net97 net33 net161 VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__o21ai_1
X_1485_ _0753_ _0754_ net156 VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__o21bai_1
.ends
